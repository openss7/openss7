/*****************************************************************************

 @(#) $RCSfile$ $Name$($Revision$) $Date$

 -----------------------------------------------------------------------------

 Copyright (c) 2001-2007  OpenSS7 Corporation <http://www.openss7.com/>
 Copyright (c) 1997-2000  Brian F. G. Bidulock <bidulock@openss7.org>

 All Rights Reserved.

 This program is free software: you can redistribute it and/or modify it under
 the terms of the GNU General Public License as published by the Free Software
 Foundation, version 3 of the license.

 This program is distributed in the hope that it will be useful, but WITHOUT
 ANY WARRANTY; without even the implied warranty of MERCHANTABILITY or FITNESS
 FOR A PARTICULAR PURPOSE.  See the GNU General Public License for more
 details.

 You should have received a copy of the GNU General Public License along with
 this program.  If not, see <http://www.gnu.org/licenses/>, or write to the
 Free Software Foundation, Inc., 675 Mass Ave, Cambridge, MA 02139, USA.

 -----------------------------------------------------------------------------

 U.S. GOVERNMENT RESTRICTED RIGHTS.  If you are licensing this Software on
 behalf of the U.S. Government ("Government"), the following provisions apply
 to you.  If the Software is supplied by the Department of Defense ("DoD"), it
 is classified as "Commercial Computer Software" under paragraph 252.227-7014
 of the DoD Supplement to the Federal Acquisition Regulations ("DFARS") (or any
 successor regulations) and the Government is acquiring only the license rights
 granted herein (the license rights customarily provided to non-Government
 users).  If the Software is supplied to any unit or agency of the Government
 other than DoD, it is classified as "Restricted Computer Software" and the
 Government's rights in the Software are defined in paragraph 52.227-19 of the
 Federal Acquisition Regulations ("FAR") (or any successor regulations) or, in
 the cases of NASA, in paragraph 18.52.227-86 of the NASA Supplement to the FAR
 (or any successor regulations).

 -----------------------------------------------------------------------------

 Commercial licensing and support of this software is available from OpenSS7
 Corporation at a fee.  See http://www.openss7.com/

 -----------------------------------------------------------------------------

 Last Modified $Date$ by $Author$

 -----------------------------------------------------------------------------

 $Log$
 *****************************************************************************/

#ident "@(#) $RCSfile$ $Name$($Revision$) $Date$"

static char const ident[] = "$RCSfile$ $Name$($Revision$) $Date$";

#ifndef lint
static char yysccsid[] = "@(#)yaccpar	1.8 (Berkeley) 01/20/90";
#endif
#define YYBYACC 1
#line 5 "yacc.y"
#ifndef	lint
static char *rcsid =
    "Header: /xtel/isode/isode/pepy/RCS/yacc.y.gnrc,v 9.0 1992/06/16 12:25:01 isode Rel";
#endif

/* 
 * Header: /xtel/isode/isode/pepy/RCS/yacc.y.gnrc,v 9.0 1992/06/16 12:25:01 isode Rel
 *
 *
 * Log: yacc.y.gnrc,v
 * Revision 9.0  1992/06/16  12:25:01  isode
 * Release 8.0
 *
 */

/*
 *				  NOTICE
 *
 *    Acquisition, use, and distribution of this module and related
 *    materials are subject to the restrictions of a license agreement.
 *    Consult the Preface in the User's Manual for the full terms of
 *    this agreement.
 *
 */

#include <stdio.h>
#include <ctype.h>
#include "pepy.h"

#define	YYSTYPE	YYSTKTYPE

#define	YYDEBUG	1

extern int pepydebug;
extern int doexternals;

int tagcontrol = TAG_UNKNOWN;
static int tagdefault;
static int listtype;
static OID modid;

static int yyporting = 0;

typedef struct ypa {
	char *ya_text;
	int ya_lineno;
} ypa, *YA;

#define	NULLYA	((YA) 0)
extern double pow();

static YA
new_action(text, lineno)
	char *text;
	int lineno;
{
	register YA ya;

	if ((ya = (YA) calloc(1, sizeof *ya)) == NULLYA)
		yyerror("out of memory");

	ya->ya_text = text;
	ya->ya_lineno = lineno;

	return ya;
}

#define	free_action(ya)	(void) free ((char *) (ya))

typedef struct {
	char *ys_structname;
	char *ys_ptrname;
} ysa, *YS;

#define NULLYS ((YS) 0)

static YS
new_ys(str)
	char *str;
{
	register YS ys;
	register char *p, *q;
	char c;

	if ((ys = (YS) malloc(sizeof *ys)) == NULLYS)
		yyerror("out of memory");
	q = str;
	while (isspace((u_char) *q))
		q++;
	for (p = q; isalnum((u_char) *p) || *p == '_'; p++)
		continue;
	if (*p != '\0') {
		c = *p;
		*p = '\0';
		ys->ys_structname = new_string(q);
		*p = c;
	} else {
		ys->ys_structname = new_string(q);
		ys->ys_ptrname = NULLCP;
		free(str);
		return ys;
	}
	for (q = p; *q != '$'; q++)
		if (!*q) {
			free(str);
			ys->ys_ptrname = NULLCP;
			return ys;
		}
	q++;
	while (isspace((u_char) *q))
		q++;
	for (p = q; isalnum((u_char) *p) || *p == '_'; p++)
		continue;
	*p = '\0';
	ys->ys_ptrname = new_string(q);
	free(str);
	return ys;
}

#define	free_ys(ys) (void) free ((char *) (ys))

static int final_actions = 0;

#line 126 "yacc.y"
typedef union {
	int yy_number;
	char *yy_string;
	YP yy_type;
	YV yy_value;
	YT yy_tag;
	YA yy_action;
	OID yy_oid;
	YS yy_sctrl;
	double yy_real;
} YYSTYPE;

#line 135 "y.tab.c"
#define ABSENT 257
#define ACTION 258
#define ANY 259
#define APPLICATION 260
#define BAR 261
#define BGIN 262
#define BIT 263
#define BITSTRING 264
#define BOOLEAN 265
#define BY 266
#define CCE 267
#define CHOICE 268
#define COMMA 269
#define COMPONENT 270
#define COMPONENTS 271
#define COMPONENTSOF 272
#define CONTROL 273
#define DECODER 274
#define DEFAULT 275
#define DEFINED 276
#define DEFINITIONS 277
#define DOT 278
#define DOTDOT 279
#define DOTDOTDOT 280
#define ENCODER 281
#define ENCRYPTED 282
#define END 283
#define ENUMERATED 284
#define EXPORTS 285
#define EXPLICIT 286
#define L_FALSE 287
#define FROM 288
#define ID 289
#define IDENTIFIER 290
#define IMPLICIT 291
#define IMPORTS 292
#define INCLUDES 293
#define INTEGER 294
#define LANGLE 295
#define LBRACE 296
#define LBRACKET 297
#define LITNUMBER 298
#define LITSTRING 299
#define LPAREN 300
#define MIN 301
#define MAX 302
#define NAME 303
#define NIL 304
#define OBJECT 305
#define OCTET 306
#define OCTETSTRING 307
#define OF 308
#define OPTIONAL 309
#define PARAMETERTYPE 310
#define PREFIXES 311
#define PRESENT 312
#define PRINTER 313
#define PRIVATE 314
#define RBRACE 315
#define RBRACKET 316
#define REAL 317
#define RPAREN 318
#define SECTIONS 319
#define SEMICOLON 320
#define SEQUENCE 321
#define SEQUENCEOF 322
#define SET 323
#define SETOF 324
#define SIZE 325
#define STRING 326
#define TAGS 327
#define L_TRUE 328
#define UNIVERSAL 329
#define VALA 330
#define VALB 331
#define VALI 332
#define VALS 333
#define VALP 334
#define VALO 335
#define VALOID 336
#define VALR 337
#define VALQ 338
#define VALX 339
#define VLENGTH 340
#define WITH 341
#define SCTRL 342
#define PLUSINFINITY 343
#define MINUSINFINITY 344
#define YYERRCODE 256
short yylhs[] = { -1,
	53, 56, 0, 51, 51, 51, 13, 58, 58, 52,
	52, 54, 54, 55, 63, 59, 59, 62, 62, 65,
	60, 60, 64, 64, 66, 66, 67, 15, 15, 14,
	14, 61, 61, 68, 68, 68, 68, 68, 7, 7,
	69, 69, 70, 16, 16, 16, 44, 44, 5, 5,
	4, 4, 17, 17, 17, 17, 17, 17, 17, 17,
	17, 17, 17, 17, 17, 17, 17, 17, 17, 17,
	17, 17, 17, 41, 41, 18, 18, 19, 19, 19,
	19, 19, 19, 76, 76, 10, 10, 11, 11, 9,
	9, 8, 8, 20, 20, 21, 21, 21, 21, 12,
	12, 22, 6, 6, 31, 31, 32, 33, 33, 23,
	23, 29, 29, 24, 24, 25, 25, 25, 25, 25,
	26, 26, 27, 28, 28, 42, 43, 43, 43, 43,
	71, 34, 34, 35, 35, 35, 35, 35, 35, 35,
	35, 35, 35, 1, 1, 3, 3, 2, 36, 36,
	36, 37, 37, 38, 38, 39, 39, 40, 57, 73,
	73, 72, 72, 74, 74, 75, 75, 77, 77, 46,
	45, 45, 47, 47, 48, 48, 49, 30, 30, 30,
	78, 80, 80, 81, 81, 82, 82, 82, 82, 83,
	83, 84, 85, 88, 88, 89, 89, 90, 90, 91,
	91, 79, 86, 87, 87, 92, 93, 93, 94, 95,
	96, 96, 97, 97, 98, 98, 98, 99, 100, 100,
	50, 50,
};
short yylen[] = { 2,
	0, 0, 12, 2, 2, 1, 2, 1, 1, 1,
	1, 4, 1, 3, 0, 4, 1, 1, 1, 0,
	4, 1, 1, 1, 2, 1, 3, 3, 1, 1,
	1, 3, 1, 2, 2, 2, 4, 1, 1, 1,
	1, 1, 6, 2, 2, 2, 1, 1, 1, 1,
	1, 1, 2, 3, 5, 3, 2, 1, 3, 5,
	6, 3, 5, 6, 4, 4, 3, 7, 3, 2,
	3, 2, 2, 3, 1, 3, 5, 1, 1, 1,
	2, 1, 1, 1, 4, 1, 1, 1, 1, 1,
	1, 1, 1, 2, 1, 1, 2, 1, 1, 1,
	1, 1, 1, 1, 1, 3, 5, 1, 1, 1,
	1, 1, 1, 1, 3, 1, 3, 4, 1, 2,
	3, 1, 2, 1, 3, 4, 1, 1, 1, 1,
	4, 1, 1, 1, 1, 1, 4, 1, 1, 3,
	2, 2, 1, 1, 1, 1, 1, 7, 1, 1,
	3, 3, 1, 1, 1, 1, 3, 1, 0, 2,
	1, 1, 2, 1, 2, 1, 2, 1, 2, 3,
	1, 2, 1, 1, 1, 1, 4, 2, 7, 7,
	4, 1, 1, 3, 1, 1, 1, 1, 1, 1,
	1, 2, 3, 1, 2, 1, 2, 1, 1, 1,
	1, 2, 2, 3, 3, 1, 1, 1, 3, 5,
	1, 3, 2, 1, 1, 1, 1, 1, 1, 1,
	1, 1,
};
short yydefred[] = { 0,
	0, 0, 0, 0, 8, 9, 7, 0, 0, 175,
	0, 176, 0, 171, 173, 174, 0, 0, 0, 6,
	0, 0, 170, 172, 4, 5, 1, 151, 150, 0,
	0, 177, 10, 0, 11, 0, 0, 13, 39, 40,
	0, 0, 0, 15, 0, 17, 0, 12, 0, 2,
	20, 22, 159, 30, 31, 29, 0, 19, 0, 0,
	0, 33, 0, 0, 16, 3, 0, 24, 0, 0,
	26, 0, 0, 0, 0, 38, 0, 28, 0, 21,
	25, 35, 34, 36, 0, 0, 0, 32, 41, 42,
	27, 0, 51, 0, 52, 0, 0, 162, 0, 0,
	0, 0, 0, 0, 0, 0, 58, 0, 0, 161,
	0, 0, 164, 0, 166, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 0, 37, 47, 0, 48, 0,
	163, 90, 53, 91, 221, 0, 222, 0, 92, 0,
	93, 0, 78, 79, 80, 96, 0, 82, 98, 0,
	0, 83, 99, 102, 0, 128, 129, 127, 0, 130,
	0, 0, 160, 100, 73, 101, 165, 0, 0, 0,
	167, 0, 0, 0, 0, 178, 44, 45, 46, 0,
	0, 0, 95, 57, 0, 0, 88, 70, 89, 0,
	0, 0, 0, 0, 97, 81, 103, 76, 104, 0,
	54, 75, 108, 0, 109, 0, 86, 71, 87, 202,
	59, 0, 0, 0, 62, 0, 0, 135, 0, 0,
	136, 138, 0, 0, 134, 146, 147, 143, 144, 145,
	0, 131, 132, 133, 0, 0, 199, 0, 0, 190,
	0, 182, 183, 187, 188, 189, 191, 0, 0, 0,
	0, 0, 94, 56, 0, 0, 0, 85, 49, 0,
	50, 0, 0, 105, 0, 0, 126, 0, 0, 0,
	0, 0, 0, 0, 158, 0, 0, 156, 155, 141,
	142, 203, 0, 0, 0, 0, 185, 0, 0, 195,
	0, 0, 0, 0, 0, 0, 0, 0, 55, 77,
	74, 0, 168, 0, 0, 0, 0, 114, 0, 119,
	111, 0, 0, 0, 0, 113, 0, 0, 0, 0,
	0, 140, 0, 206, 204, 0, 205, 207, 208, 0,
	181, 0, 201, 200, 193, 196, 0, 0, 0, 124,
	0, 0, 106, 169, 120, 0, 61, 0, 0, 0,
	0, 0, 64, 0, 0, 137, 0, 157, 220, 0,
	0, 219, 217, 218, 0, 0, 214, 215, 216, 184,
	197, 0, 68, 0, 0, 115, 0, 117, 0, 0,
	152, 0, 0, 213, 209, 0, 125, 107, 118, 0,
	0, 212, 148, 210,
};
short yydgoto[] = { 2,
	228, 229, 230, 94, 260, 198, 41, 140, 133, 208,
	188, 165, 3, 56, 67, 231, 117, 118, 151, 182,
	152, 153, 306, 307, 308, 309, 310, 341, 315, 119,
	263, 264, 204, 239, 233, 234, 319, 276, 277, 278,
	201, 120, 159, 346, 13, 5, 14, 15, 16, 136,
	19, 34, 31, 37, 45, 60, 129, 7, 47, 53,
	63, 59, 49, 69, 61, 70, 71, 77, 88, 89,
	90, 121, 122, 123, 124, 125, 312, 176, 240, 241,
	288, 242, 243, 244, 245, 246, 247, 248, 335, 249,
	336, 325, 327, 328, 329, 365, 366, 367, 368, 369,
};
short yysindex[] = { -265,
	-264, 0, -233, -134, 0, 0, 0, -99, -211, 0,
	-206, 0, 16, 0, 0, 0, -271, -232, -171, 0,
	-173, -67, 0, 0, 0, 0, 0, 0, 0, -160,
	-88, 0, 0, -146, 0, -129, -82, 0, 0, 0,
	-129, -97, -129, 0, -69, 0, -59, 0, -113, 0,
	0, 0, 0, 0, 0, 0, -28, 0, -75, -88,
	-113, 0, -108, -113, 0, 0, -176, 0, -58, -113,
	0, -129, -129, -129, -129, 0, -93, 0, -265, 0,
	0, 0, 0, 0, -129, -63, 2234, 0, 0, 0,
	0, -129, 0, -7, 0, -15, -50, 0, -78, -74,
	2234, -46, -191, -46, -243, -17, 0, 1, -36, 0,
	-45, -96, 0, -76, 0, -249, -7, -7, -7, -7,
	-32, -312, -74, -74, -27, 0, 0, 42, 0, 44,
	0, 0, 0, 0, 0, -7, 0, 13, 0, 37,
	0, 26, 0, 0, 0, 0, 2, 0, 0, 3,
	5, 0, 0, 0, 49, 0, 0, 0, 38, 0,
	2234, 4, 0, 0, 0, 0, 0, 13, -253, 36,
	0, -253, 40, 1834, 1579, 0, 0, 0, 0, 2002,
	10, 49, 0, 0, -7, -7, 0, 0, 0, -7,
	54, 79, 62, 23, 0, 0, 0, 0, 0, 62,
	0, 0, 0, 51, 0, 13, 0, 0, 0, 0,
	0, 75, 0, -74, 0, 81, -74, 0, -132, 1885,
	0, 0, 1681, 0, 0, 0, 0, 0, 0, 0,
	1732, 0, 0, 0, 13, 2234, 0, -136, 0, 0,
	114, 0, 0, 0, 0, 0, 0, 99, 86, 2234,
	2234, 13, 0, 0, 79, 79, 2234, 0, 0, 87,
	0, 84, -247, 0, 5, -240, 0, 2068, -7, 2068,
	-7, 101, -132, 122, 0, 78, 126, 0, 0, 0,
	0, 0, 13, 13, 100, 1579, 0, 80, 1630, 0,
	13, 13, 2234, 2234, 13, 2284, 38, 62, 0, 0,
	0, 89, 0, -86, 13, 85, 137, 0, -267, 0,
	0, 2234, 79, 137, 92, 0, 79, 23, -235, 0,
	115, 0, 1834, 0, 0, -222, 0, 0, 0, 114,
	0, 1783, 0, 0, 0, 0, 13, 13, -238, 0,
	-231, 97, 0, 0, 0, 2234, 0, 2068, 1834, 79,
	13, 2234, 0, 2234, 127, 0, 148, 0, 0, 150,
	-183, 0, 0, 0, 106, 156, 0, 0, 0, 0,
	0, 2284, 0, -7, 13, 0, 79, 0, 13, 13,
	0, 132, -203, 0, 0, -203, 0, 0, 0, 116,
	117, 0, 0, 0,
};
short yyrindex[] = { 0,
	-95, 0, 0, 0, 0, 0, 0, 167, 8, 0,
	32, 0, 0, 0, 0, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
	-256, 0, 0, 176, 0, 0, 0, 0, 0, 0,
	0, -18, 0, 0, 0, 0, 15, 0, 120, 0,
	0, 0, 0, 0, 0, 0, 124, 0, 0, 450,
	120, 0, -175, 0, 0, 0, 0, 0, 0, 131,
	0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 0, -23, 0, 0, 0, 0,
	0, 0, 0, 167, 0, 105, 0, 0, 458, -121,
	0, 158, 178, 458, 48, 0, 0, 0, 0, 0,
	458, 250, 0, 250, 0, 0, 1513, 1513, 1513, 2118,
	458, 458, 1952, 1952, 458, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 0, -257, 0, 668, 0, 0,
	0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
	458, 0, 0, 0, 739, 0, 0, 0, 0, 0,
	0, 458, 0, 0, 0, 0, 0, 0, 1513, 0,
	0, 1513, 0, 0, 0, 0, 0, 0, 0, 0,
	0, 739, 0, 0, 2184, 2184, 0, 0, 0, 2334,
	0, 158, 0, 178, 0, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 0, 810, 0, 0, 0, 0,
	0, 0, 529, 1952, 0, 0, 1952, 0, 318, 140,
	0, 0, -31, 597, 0, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 0, 0, 0, 0, -248, 0,
	138, 0, 0, 0, 0, 0, 0, 0, 179, 0,
	0, 881, 0, 0, 2334, 2334, 0, 0, 0, 0,
	0, 0, 0, 0, 458, 0, 0, 140, 2184, 140,
	2184, 0, 1374, 142, 0, 0, 149, 0, 0, 0,
	0, 0, -246, 0, 0, 0, 0, 0, 0, 0,
	952, 1023, 0, 0, 19, 0, 0, 0, 0, 0,
	0, 0, 0, 2334, -226, 0, 151, 0, -224, 0,
	0, 0, 2334, 153, 0, 0, 2334, 386, 0, 1441,
	0, 0, 0, 0, 0, -177, 0, 0, 0, 138,
	0, 0, 0, 0, 0, 0, 1094, 1165, 2334, 0,
	0, 0, 0, 0, 0, 0, 0, 0, 0, -177,
	-164, 0, 0, 0, 0, 0, 0, 0, 0, 0,
	-177, 0, 0, 0, 0, 154, 0, 0, 0, 0,
	0, 0, 0, -177, -126, 0, -177, 0, 1236, 1307,
	0, 0, -177, 0, 0, -177, 0, 0, 0, 0,
	0, 0, 0, 0,
};
short yygindex[] = { 0,
	0, 0, 0, 0, -244, 198, 185, 366, 0, 0,
	65, 0, 392, 409, 430, -73, 0, 0, -192, 0,
	358, 365, 0, 218, 141, -293, 186, 0, 0, 0,
	292, 196, 201, -170, 0, -3, 0, 0, 0, 180,
	322, 0, 0, -54, 0, 0, 492, 485, 0, -87,
	0, 456, 0, 0, 0, 0, -1, 0, 0, 0,
	0, 0, 0, 0, 0, 0, 440, 0, 0, 0,
	0, 0, 0, 0, 0, 0, 0, -159, 45, 234,
	193, 0, 0, 0, 0, 0, 0, 0, 0, 0,
	194, 0, 0, 0, 0, -103, 0, 166, 0, 0,
};

#define YYTABLESIZE 2658
short yytable[] = { 6,
	12, 265, 340, 232, 127, 159, 20, 349, 210, 12,
	293, 294, 186, 116, 192, 159, 156, 174, 12, 127,
	146, 298, 147, 1, 169, 149, 172, 138, 298, 35,
	198, 4, 38, 355, 359, 185, 186, 372, 159, 128,
	46, 350, 122, 8, 116, 52, 198, 58, 122, 275,
	175, 62, 280, 359, 159, 25, 161, 360, 35, 68,
	281, 76, 177, 178, 179, 180, 21, 299, 352, 186,
	157, 192, 354, 359, 301, 282, 187, 175, 387, 356,
	361, 192, 122, 373, 95, 158, 142, 206, 122, 362,
	116, 159, 64, 22, 26, 27, 175, 134, 137, 361,
	141, 154, 141, 160, 123, 378, 252, 14, 362, 166,
	137, 79, 137, 159, 212, 28, 175, 216, 334, 154,
	154, 137, 137, 189, 324, 265, 269, 159, 362, 271,
	255, 256, 389, 284, 285, 257, 159, 159, 143, 144,
	145, 146, 121, 147, 148, 272, 149, 150, 121, 199,
	123, 159, 275, 202, 9, 205, 170, 32, 173, 39,
	209, 334, 283, 10, 36, 72, 364, 213, 11, 33,
	213, 127, 73, 40, 159, 54, 291, 292, 377, 42,
	202, 159, 121, 295, 302, 303, 17, 44, 121, 55,
	261, 18, 154, 159, 305, 86, 305, 143, 144, 145,
	146, 364, 147, 148, 74, 149, 150, 159, 161, 87,
	75, 167, 137, 50, 313, 137, 317, 154, 279, 337,
	338, 9, 305, 364, 159, 43, 364, 48, 168, 150,
	10, 171, 51, 211, 159, 29, 215, 150, 351, 287,
	64, 150, 150, 159, 65, 135, 93, 150, 168, 150,
	127, 150, 132, 261, 261, 159, 82, 83, 84, 85,
	130, 80, 159, 199, 159, 135, 311, 135, 316, 92,
	159, 320, 375, 159, 305, 131, 126, 161, 379, 391,
	380, 150, 392, 150, 159, 139, 150, 150, 159, 163,
	162, 164, 43, 205, 159, 159, 149, 159, 305, 43,
	159, 43, 187, 159, 9, 149, 181, 43, 190, 191,
	149, 261, 175, 10, 194, 261, 154, 159, 11, 388,
	150, 43, 149, 149, 363, 149, 9, 159, 287, 150,
	23, 43, 193, 159, 150, 203, 159, 43, 197, 207,
	29, 195, 196, 214, 200, 159, 150, 217, 261, 253,
	159, 259, 143, 144, 145, 146, 258, 147, 148, 363,
	149, 150, 84, 84, 262, 84, 267, 84, 84, 84,
	268, 84, 84, 84, 286, 261, 270, 289, 84, 84,
	290, 363, 296, 297, 363, 84, 84, 84, 84, 318,
	321, 84, 322, 84, 323, 326, 344, 331, 84, 347,
	84, 84, 84, 84, 84, 348, 353, 84, 84, 84,
	84, 84, 357, 84, 374, 381, 382, 84, 383, 84,
	385, 84, 84, 84, 386, 84, 84, 84, 84, 390,
	393, 394, 84, 159, 84, 159, 159, 159, 159, 159,
	159, 159, 159, 18, 159, 159, 159, 84, 84, 159,
	23, 159, 159, 159, 159, 159, 136, 194, 159, 159,
	159, 159, 300, 154, 159, 110, 159, 112, 211, 155,
	91, 159, 78, 159, 159, 159, 159, 159, 57, 184,
	159, 159, 159, 159, 159, 183, 159, 314, 376, 345,
	159, 266, 159, 343, 159, 159, 159, 342, 159, 159,
	159, 159, 358, 254, 24, 159, 30, 159, 159, 81,
	159, 159, 159, 159, 159, 66, 159, 159, 159, 330,
	159, 159, 370, 159, 159, 371, 384, 0, 0, 0,
	159, 159, 159, 159, 0, 0, 159, 0, 159, 0,
	0, 0, 0, 159, 0, 159, 159, 159, 159, 159,
	0, 0, 159, 159, 159, 159, 159, 0, 159, 0,
	0, 0, 159, 0, 159, 0, 159, 159, 159, 0,
	159, 159, 159, 159, 0, 159, 159, 159, 149, 159,
	159, 159, 159, 0, 0, 159, 149, 0, 0, 0,
	149, 149, 159, 159, 0, 0, 149, 0, 149, 159,
	149, 159, 0, 0, 159, 0, 149, 0, 0, 0,
	0, 159, 149, 159, 159, 159, 159, 159, 0, 0,
	149, 159, 159, 159, 159, 0, 0, 0, 0, 0,
	149, 0, 149, 0, 159, 149, 149, 0, 159, 159,
	159, 159, 0, 159, 159, 159, 151, 0, 159, 159,
	159, 159, 0, 159, 151, 0, 0, 0, 151, 151,
	159, 159, 0, 0, 151, 0, 151, 159, 151, 159,
	0, 0, 159, 0, 151, 0, 0, 0, 0, 159,
	151, 159, 159, 159, 159, 159, 0, 0, 151, 159,
	159, 159, 159, 0, 0, 0, 0, 0, 151, 0,
	151, 0, 159, 151, 151, 0, 159, 159, 159, 159,
	0, 0, 0, 159, 0, 159, 159, 0, 159, 159,
	159, 159, 159, 0, 159, 159, 159, 0, 159, 159,
	0, 159, 159, 0, 0, 0, 0, 0, 159, 159,
	159, 159, 0, 0, 159, 0, 159, 0, 0, 0,
	0, 159, 0, 159, 159, 159, 159, 159, 0, 0,
	159, 159, 159, 159, 159, 0, 159, 0, 0, 0,
	159, 0, 159, 0, 159, 159, 159, 0, 159, 159,
	159, 159, 0, 0, 0, 159, 89, 89, 0, 89,
	0, 89, 89, 89, 0, 89, 89, 89, 0, 0,
	159, 159, 89, 89, 0, 0, 0, 0, 0, 89,
	89, 89, 89, 0, 0, 89, 0, 89, 0, 0,
	0, 0, 89, 0, 48, 89, 89, 89, 89, 0,
	0, 89, 89, 89, 89, 89, 0, 89, 0, 0,
	0, 89, 0, 89, 0, 89, 89, 89, 0, 89,
	89, 89, 89, 0, 58, 58, 89, 139, 0, 58,
	58, 58, 0, 0, 58, 139, 0, 0, 0, 139,
	139, 89, 89, 0, 0, 139, 0, 139, 58, 139,
	58, 0, 0, 58, 0, 58, 0, 0, 0, 0,
	58, 139, 58, 58, 58, 58, 58, 0, 0, 58,
	58, 58, 58, 58, 0, 0, 0, 0, 0, 139,
	0, 139, 0, 58, 139, 139, 0, 58, 58, 58,
	58, 0, 0, 0, 58, 72, 72, 0, 72, 0,
	72, 72, 72, 0, 72, 72, 72, 0, 0, 58,
	58, 72, 72, 0, 0, 0, 0, 0, 72, 72,
	72, 72, 0, 0, 72, 0, 72, 0, 0, 0,
	0, 72, 0, 72, 72, 72, 72, 0, 0, 0,
	72, 72, 72, 72, 72, 0, 72, 0, 0, 0,
	72, 0, 72, 0, 72, 72, 72, 0, 72, 72,
	72, 72, 0, 0, 0, 72, 159, 159, 0, 159,
	0, 159, 159, 159, 0, 159, 159, 159, 0, 0,
	72, 72, 159, 159, 0, 0, 0, 0, 0, 159,
	159, 159, 159, 0, 0, 159, 0, 159, 0, 0,
	0, 0, 159, 0, 0, 159, 159, 159, 159, 0,
	0, 159, 159, 159, 159, 159, 0, 159, 0, 0,
	0, 159, 0, 159, 0, 159, 159, 159, 0, 159,
	159, 159, 159, 0, 0, 0, 159, 69, 69, 0,
	69, 0, 69, 69, 69, 0, 69, 69, 69, 0,
	0, 159, 159, 69, 69, 0, 0, 0, 0, 0,
	69, 69, 69, 69, 0, 0, 69, 0, 69, 0,
	0, 0, 0, 69, 0, 69, 69, 69, 69, 0,
	0, 0, 69, 69, 69, 69, 69, 0, 69, 0,
	0, 0, 69, 0, 69, 0, 69, 69, 69, 0,
	69, 69, 69, 69, 0, 0, 0, 69, 67, 67,
	0, 67, 0, 67, 67, 67, 0, 67, 67, 67,
	0, 0, 69, 69, 67, 67, 0, 0, 0, 0,
	0, 67, 67, 67, 67, 0, 0, 67, 0, 67,
	0, 0, 0, 0, 67, 0, 67, 67, 67, 67,
	0, 0, 0, 67, 67, 67, 67, 67, 0, 67,
	0, 0, 0, 67, 0, 67, 0, 67, 67, 67,
	0, 67, 67, 67, 67, 0, 0, 0, 67, 66,
	66, 0, 66, 0, 66, 66, 66, 0, 66, 66,
	66, 0, 0, 67, 67, 66, 66, 0, 0, 0,
	0, 0, 66, 66, 66, 66, 0, 0, 66, 0,
	66, 0, 0, 0, 0, 66, 0, 66, 66, 66,
	66, 0, 0, 0, 66, 66, 66, 66, 66, 0,
	66, 0, 0, 0, 66, 0, 66, 0, 66, 66,
	66, 0, 66, 66, 66, 66, 0, 0, 0, 66,
	65, 65, 0, 65, 0, 65, 65, 65, 0, 65,
	65, 65, 0, 0, 66, 66, 65, 65, 0, 0,
	0, 0, 0, 65, 65, 65, 65, 0, 0, 65,
	0, 65, 0, 0, 0, 0, 65, 0, 65, 65,
	65, 65, 0, 0, 0, 65, 65, 65, 65, 65,
	0, 65, 0, 0, 0, 65, 0, 65, 0, 65,
	65, 65, 0, 65, 65, 65, 65, 0, 0, 0,
	65, 60, 60, 0, 60, 0, 60, 60, 60, 0,
	60, 60, 60, 0, 0, 65, 65, 60, 60, 0,
	0, 0, 0, 0, 60, 60, 60, 60, 0, 0,
	60, 0, 60, 0, 0, 0, 0, 60, 0, 60,
	60, 60, 60, 0, 0, 0, 60, 60, 60, 60,
	60, 0, 60, 0, 0, 0, 60, 0, 60, 0,
	60, 60, 60, 0, 60, 60, 60, 60, 0, 0,
	0, 60, 63, 63, 0, 63, 0, 63, 63, 63,
	0, 63, 63, 63, 0, 0, 60, 60, 63, 63,
	0, 0, 0, 0, 0, 63, 63, 63, 63, 0,
	0, 63, 0, 63, 0, 0, 0, 0, 63, 0,
	63, 63, 63, 63, 0, 0, 0, 63, 63, 63,
	63, 63, 0, 63, 0, 0, 0, 63, 0, 63,
	0, 63, 63, 63, 0, 63, 63, 63, 63, 0,
	0, 0, 63, 180, 180, 0, 180, 0, 180, 180,
	180, 0, 180, 180, 180, 0, 0, 63, 63, 180,
	180, 0, 0, 0, 0, 0, 180, 180, 180, 180,
	0, 0, 180, 0, 180, 0, 0, 0, 0, 180,
	0, 180, 180, 180, 180, 0, 0, 0, 180, 180,
	180, 180, 180, 0, 180, 0, 0, 0, 180, 0,
	180, 0, 180, 180, 180, 0, 180, 180, 180, 180,
	0, 0, 0, 180, 179, 179, 0, 179, 0, 179,
	179, 179, 0, 179, 179, 179, 0, 0, 180, 180,
	179, 179, 0, 0, 0, 0, 0, 179, 179, 179,
	179, 0, 0, 179, 0, 179, 0, 0, 0, 0,
	179, 0, 179, 179, 179, 179, 0, 0, 0, 179,
	179, 179, 179, 179, 0, 179, 0, 0, 0, 179,
	0, 179, 0, 179, 179, 179, 0, 179, 179, 179,
	179, 159, 159, 0, 179, 0, 159, 159, 159, 0,
	0, 159, 149, 0, 0, 0, 0, 0, 0, 179,
	179, 0, 0, 0, 0, 159, 0, 159, 0, 0,
	159, 0, 159, 0, 0, 0, 0, 159, 0, 159,
	159, 159, 159, 159, 0, 0, 159, 159, 159, 159,
	159, 0, 0, 0, 0, 0, 0, 0, 149, 0,
	159, 0, 0, 0, 159, 159, 159, 159, 102, 102,
	0, 159, 0, 102, 102, 102, 0, 159, 102, 153,
	0, 0, 0, 0, 0, 0, 159, 159, 0, 0,
	0, 0, 102, 0, 102, 0, 0, 102, 0, 102,
	0, 0, 0, 0, 102, 0, 102, 102, 102, 102,
	102, 0, 0, 102, 102, 102, 102, 102, 0, 0,
	0, 0, 0, 0, 0, 153, 0, 102, 0, 0,
	0, 102, 102, 102, 102, 0, 0, 0, 102, 0,
	0, 159, 0, 159, 102, 159, 159, 159, 0, 159,
	159, 159, 0, 102, 102, 0, 159, 159, 0, 0,
	0, 0, 0, 159, 159, 159, 159, 0, 0, 159,
	0, 159, 0, 0, 0, 0, 159, 0, 159, 159,
	159, 159, 159, 0, 0, 159, 159, 159, 159, 159,
	0, 159, 0, 0, 0, 159, 0, 159, 0, 159,
	159, 159, 0, 159, 159, 159, 159, 96, 0, 0,
	159, 97, 98, 99, 0, 0, 100, 0, 0, 0,
	0, 0, 0, 0, 0, 159, 159, 0, 0, 0,
	101, 0, 102, 0, 0, 218, 235, 219, 0, 0,
	0, 236, 104, 0, 220, 105, 221, 222, 0, 237,
	0, 223, 224, 108, 109, 110, 0, 0, 96, 0,
	0, 0, 97, 98, 99, 111, 0, 100, 0, 112,
	113, 114, 115, 168, 0, 0, 225, 0, 0, 0,
	0, 101, 0, 102, 0, 0, 218, 0, 219, 238,
	0, 226, 227, 104, 332, 220, 105, 221, 222, 0,
	0, 333, 223, 224, 108, 109, 110, 0, 0, 96,
	0, 0, 0, 97, 98, 99, 111, 0, 100, 0,
	112, 113, 114, 115, 0, 0, 0, 225, 0, 0,
	0, 0, 101, 0, 102, 0, 0, 218, 0, 219,
	0, 0, 226, 227, 104, 161, 220, 105, 221, 222,
	0, 0, 0, 223, 224, 108, 109, 110, 0, 0,
	96, 0, 0, 0, 97, 98, 99, 111, 0, 100,
	0, 112, 113, 114, 115, 0, 0, 0, 225, 0,
	0, 0, 0, 101, 0, 102, 0, 0, 218, 0,
	219, 0, 0, 226, 227, 104, 0, 220, 105, 221,
	222, 175, 0, 0, 223, 224, 108, 109, 110, 0,
	0, 96, 0, 0, 0, 97, 98, 99, 111, 0,
	100, 0, 112, 113, 114, 115, 0, 0, 0, 225,
	0, 0, 0, 0, 101, 0, 102, 0, 0, 218,
	0, 219, 0, 0, 226, 227, 104, 0, 220, 105,
	221, 222, 0, 0, 333, 223, 224, 108, 109, 110,
	0, 0, 96, 0, 0, 0, 97, 98, 99, 111,
	0, 100, 0, 112, 113, 114, 115, 0, 0, 0,
	225, 0, 0, 0, 0, 101, 0, 102, 0, 0,
	218, 0, 219, 0, 0, 226, 227, 104, 0, 220,
	105, 221, 222, 0, 0, 0, 223, 224, 108, 109,
	110, 0, 0, 96, 0, 0, 0, 97, 98, 99,
	111, 0, 100, 0, 112, 113, 114, 115, 0, 0,
	0, 225, 0, 0, 0, 0, 101, 0, 102, 0,
	0, 218, 0, 273, 0, 0, 226, 227, 104, 0,
	220, 105, 274, 222, 0, 0, 0, 223, 224, 108,
	109, 110, 0, 0, 0, 0, 0, 0, 0, 0,
	0, 111, 0, 0, 0, 112, 113, 114, 115, 159,
	159, 0, 225, 0, 159, 159, 159, 0, 0, 159,
	0, 0, 0, 0, 159, 0, 0, 226, 227, 0,
	0, 0, 0, 159, 0, 159, 0, 0, 0, 0,
	159, 0, 0, 0, 0, 159, 0, 0, 159, 0,
	0, 0, 0, 0, 159, 159, 159, 159, 159, 0,
	96, 0, 0, 0, 97, 98, 99, 0, 159, 100,
	0, 0, 159, 159, 159, 159, 0, 0, 0, 0,
	0, 0, 0, 101, 0, 102, 0, 250, 0, 0,
	103, 0, 251, 0, 0, 104, 0, 0, 105, 0,
	0, 0, 0, 0, 106, 107, 108, 109, 110, 0,
	0, 0, 0, 0, 0, 0, 0, 0, 111, 0,
	0, 0, 112, 113, 114, 115, 96, 0, 0, 0,
	97, 98, 99, 0, 0, 100, 0, 0, 302, 303,
	0, 0, 0, 0, 0, 0, 0, 0, 0, 101,
	0, 102, 0, 0, 0, 0, 103, 0, 0, 0,
	0, 104, 0, 0, 105, 0, 0, 0, 0, 0,
	304, 107, 108, 109, 110, 0, 159, 0, 0, 0,
	159, 159, 159, 0, 111, 159, 0, 0, 112, 113,
	114, 115, 0, 0, 0, 0, 0, 0, 0, 159,
	0, 159, 0, 159, 0, 0, 159, 0, 159, 0,
	0, 159, 0, 0, 159, 0, 0, 0, 0, 0,
	159, 159, 159, 159, 159, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 159, 0, 0, 0, 159, 159,
	159, 159, 159, 0, 0, 0, 159, 159, 159, 0,
	0, 159, 0, 0, 0, 0, 159, 0, 0, 0,
	0, 0, 0, 0, 0, 159, 0, 159, 0, 0,
	0, 0, 159, 0, 0, 0, 0, 159, 0, 0,
	159, 0, 0, 0, 0, 0, 159, 159, 159, 159,
	159, 0, 96, 0, 0, 0, 97, 98, 99, 0,
	159, 100, 0, 0, 159, 159, 159, 159, 0, 0,
	0, 0, 0, 0, 0, 101, 0, 102, 0, 0,
	0, 0, 103, 0, 0, 0, 0, 104, 0, 0,
	105, 0, 0, 0, 0, 0, 106, 107, 108, 109,
	110, 0, 96, 0, 0, 0, 97, 98, 99, 0,
	111, 100, 0, 0, 112, 113, 114, 115, 0, 0,
	0, 0, 0, 0, 0, 101, 0, 102, 0, 0,
	0, 0, 103, 0, 0, 0, 0, 104, 0, 0,
	105, 0, 0, 0, 0, 0, 339, 107, 108, 109,
	110, 0, 159, 0, 0, 0, 159, 159, 159, 0,
	111, 159, 0, 0, 112, 113, 114, 115, 0, 0,
	0, 0, 0, 0, 0, 159, 0, 159, 0, 0,
	0, 0, 159, 0, 0, 0, 0, 159, 0, 0,
	159, 0, 0, 0, 0, 0, 159, 159, 159, 159,
	159, 0, 0, 0, 0, 0, 0, 0, 0, 0,
	159, 0, 0, 0, 159, 159, 159, 159,
};
short yycheck[] = { 1,
	4, 194, 296, 174, 258, 262, 8, 275, 168, 13,
	255, 256, 261, 87, 261, 273, 260, 267, 22, 258,
	333, 269, 335, 289, 112, 338, 114, 101, 269, 31,
	279, 296, 34, 269, 257, 123, 124, 269, 296, 94,
	42, 309, 269, 277, 269, 47, 295, 49, 275, 220,
	300, 53, 223, 257, 311, 327, 295, 280, 60, 61,
	231, 63, 117, 118, 119, 120, 278, 315, 313, 318,
	314, 318, 317, 257, 315, 235, 330, 300, 372, 315,
	303, 136, 309, 315, 86, 329, 278, 161, 315, 312,
	315, 269, 269, 300, 327, 267, 300, 99, 100, 303,
	102, 103, 104, 105, 269, 350, 180, 283, 312, 111,
	112, 288, 114, 289, 169, 289, 300, 172, 289, 121,
	122, 123, 124, 125, 284, 318, 214, 303, 312, 217,
	185, 186, 377, 270, 271, 190, 258, 315, 330, 331,
	332, 333, 269, 335, 336, 278, 338, 339, 275, 151,
	315, 273, 323, 155, 289, 159, 112, 318, 114, 289,
	162, 332, 236, 298, 311, 274, 326, 169, 303, 258,
	172, 258, 281, 303, 296, 289, 250, 251, 349, 262,
	182, 277, 309, 257, 271, 272, 286, 285, 315, 303,
	192, 291, 194, 289, 268, 289, 270, 330, 331, 332,
	333, 361, 335, 336, 313, 338, 339, 303, 295, 303,
	319, 308, 214, 283, 269, 217, 271, 219, 220, 293,
	294, 289, 296, 383, 320, 41, 386, 43, 325, 261,
	298, 308, 292, 169, 258, 303, 172, 269, 312, 241,
	269, 273, 274, 267, 320, 342, 310, 279, 325, 281,
	258, 283, 331, 255, 256, 274, 72, 73, 74, 75,
	276, 320, 281, 265, 283, 342, 268, 342, 270, 85,
	289, 273, 346, 292, 348, 326, 92, 295, 352, 383,
	354, 313, 386, 315, 303, 332, 318, 319, 274, 326,
	290, 337, 274, 297, 313, 281, 289, 283, 372, 281,
	319, 283, 330, 289, 289, 298, 339, 289, 267, 266,
	303, 313, 300, 298, 289, 317, 318, 303, 303, 374,
	289, 303, 315, 316, 326, 318, 289, 313, 330, 298,
	315, 313, 296, 319, 303, 298, 289, 319, 334, 336,
	303, 340, 340, 308, 296, 298, 315, 308, 350, 340,
	303, 273, 330, 331, 332, 333, 303, 335, 336, 361,
	338, 339, 258, 259, 303, 261, 316, 263, 264, 265,
	296, 267, 268, 269, 261, 377, 296, 279, 274, 275,
	295, 383, 296, 300, 386, 281, 282, 283, 284, 289,
	269, 287, 315, 289, 269, 296, 308, 318, 294, 315,
	296, 297, 298, 299, 300, 269, 315, 303, 304, 305,
	306, 307, 298, 309, 318, 289, 269, 313, 269, 315,
	315, 317, 318, 319, 269, 321, 322, 323, 324, 298,
	315, 315, 328, 267, 330, 258, 259, 262, 261, 320,
	263, 264, 265, 320, 267, 268, 269, 343, 344, 0,
	320, 274, 275, 296, 315, 318, 315, 279, 281, 282,
	283, 284, 265, 315, 287, 315, 289, 315, 315, 104,
	79, 294, 64, 296, 297, 298, 299, 300, 49, 122,
	303, 304, 305, 306, 307, 121, 309, 270, 348, 304,
	313, 200, 315, 298, 317, 318, 319, 297, 321, 322,
	323, 324, 323, 182, 13, 328, 22, 258, 259, 70,
	261, 334, 263, 264, 265, 60, 267, 268, 269, 286,
	343, 344, 330, 274, 275, 332, 361, -1, -1, -1,
	281, 282, 283, 284, -1, -1, 287, -1, 289, -1,
	-1, -1, -1, 294, -1, 296, 297, 298, 299, 300,
	-1, -1, 303, 304, 305, 306, 307, -1, 309, -1,
	-1, -1, 313, -1, 315, -1, 317, 318, 319, -1,
	321, 322, 323, 324, -1, 258, 259, 328, 261, 330,
	263, 264, 265, -1, -1, 268, 269, -1, -1, -1,
	273, 274, 343, 344, -1, -1, 279, -1, 281, 282,
	283, 284, -1, -1, 287, -1, 289, -1, -1, -1,
	-1, 294, 295, 296, 297, 298, 299, 300, -1, -1,
	303, 304, 305, 306, 307, -1, -1, -1, -1, -1,
	313, -1, 315, -1, 317, 318, 319, -1, 321, 322,
	323, 324, -1, 258, 259, 328, 261, -1, 263, 264,
	265, 334, -1, 268, 269, -1, -1, -1, 273, 274,
	343, 344, -1, -1, 279, -1, 281, 282, 283, 284,
	-1, -1, 287, -1, 289, -1, -1, -1, -1, 294,
	295, 296, 297, 298, 299, 300, -1, -1, 303, 304,
	305, 306, 307, -1, -1, -1, -1, -1, 313, -1,
	315, -1, 317, 318, 319, -1, 321, 322, 323, 324,
	-1, -1, -1, 328, -1, 258, 259, -1, 261, 334,
	263, 264, 265, -1, 267, 268, 269, -1, 343, 344,
	-1, 274, 275, -1, -1, -1, -1, -1, 281, 282,
	283, 284, -1, -1, 287, -1, 289, -1, -1, -1,
	-1, 294, -1, 296, 297, 298, 299, 300, -1, -1,
	303, 304, 305, 306, 307, -1, 309, -1, -1, -1,
	313, -1, 315, -1, 317, 318, 319, -1, 321, 322,
	323, 324, -1, -1, -1, 328, 258, 259, -1, 261,
	-1, 263, 264, 265, -1, 267, 268, 269, -1, -1,
	343, 344, 274, 275, -1, -1, -1, -1, -1, 281,
	282, 283, 284, -1, -1, 287, -1, 289, -1, -1,
	-1, -1, 294, -1, 296, 297, 298, 299, 300, -1,
	-1, 303, 304, 305, 306, 307, -1, 309, -1, -1,
	-1, 313, -1, 315, -1, 317, 318, 319, -1, 321,
	322, 323, 324, -1, 258, 259, 328, 261, -1, 263,
	264, 265, -1, -1, 268, 269, -1, -1, -1, 273,
	274, 343, 344, -1, -1, 279, -1, 281, 282, 283,
	284, -1, -1, 287, -1, 289, -1, -1, -1, -1,
	294, 295, 296, 297, 298, 299, 300, -1, -1, 303,
	304, 305, 306, 307, -1, -1, -1, -1, -1, 313,
	-1, 315, -1, 317, 318, 319, -1, 321, 322, 323,
	324, -1, -1, -1, 328, 258, 259, -1, 261, -1,
	263, 264, 265, -1, 267, 268, 269, -1, -1, 343,
	344, 274, 275, -1, -1, -1, -1, -1, 281, 282,
	283, 284, -1, -1, 287, -1, 289, -1, -1, -1,
	-1, 294, -1, 296, 297, 298, 299, -1, -1, -1,
	303, 304, 305, 306, 307, -1, 309, -1, -1, -1,
	313, -1, 315, -1, 317, 318, 319, -1, 321, 322,
	323, 324, -1, -1, -1, 328, 258, 259, -1, 261,
	-1, 263, 264, 265, -1, 267, 268, 269, -1, -1,
	343, 344, 274, 275, -1, -1, -1, -1, -1, 281,
	282, 283, 284, -1, -1, 287, -1, 289, -1, -1,
	-1, -1, 294, -1, -1, 297, 298, 299, 300, -1,
	-1, 303, 304, 305, 306, 307, -1, 309, -1, -1,
	-1, 313, -1, 315, -1, 317, 318, 319, -1, 321,
	322, 323, 324, -1, -1, -1, 328, 258, 259, -1,
	261, -1, 263, 264, 265, -1, 267, 268, 269, -1,
	-1, 343, 344, 274, 275, -1, -1, -1, -1, -1,
	281, 282, 283, 284, -1, -1, 287, -1, 289, -1,
	-1, -1, -1, 294, -1, 296, 297, 298, 299, -1,
	-1, -1, 303, 304, 305, 306, 307, -1, 309, -1,
	-1, -1, 313, -1, 315, -1, 317, 318, 319, -1,
	321, 322, 323, 324, -1, -1, -1, 328, 258, 259,
	-1, 261, -1, 263, 264, 265, -1, 267, 268, 269,
	-1, -1, 343, 344, 274, 275, -1, -1, -1, -1,
	-1, 281, 282, 283, 284, -1, -1, 287, -1, 289,
	-1, -1, -1, -1, 294, -1, 296, 297, 298, 299,
	-1, -1, -1, 303, 304, 305, 306, 307, -1, 309,
	-1, -1, -1, 313, -1, 315, -1, 317, 318, 319,
	-1, 321, 322, 323, 324, -1, -1, -1, 328, 258,
	259, -1, 261, -1, 263, 264, 265, -1, 267, 268,
	269, -1, -1, 343, 344, 274, 275, -1, -1, -1,
	-1, -1, 281, 282, 283, 284, -1, -1, 287, -1,
	289, -1, -1, -1, -1, 294, -1, 296, 297, 298,
	299, -1, -1, -1, 303, 304, 305, 306, 307, -1,
	309, -1, -1, -1, 313, -1, 315, -1, 317, 318,
	319, -1, 321, 322, 323, 324, -1, -1, -1, 328,
	258, 259, -1, 261, -1, 263, 264, 265, -1, 267,
	268, 269, -1, -1, 343, 344, 274, 275, -1, -1,
	-1, -1, -1, 281, 282, 283, 284, -1, -1, 287,
	-1, 289, -1, -1, -1, -1, 294, -1, 296, 297,
	298, 299, -1, -1, -1, 303, 304, 305, 306, 307,
	-1, 309, -1, -1, -1, 313, -1, 315, -1, 317,
	318, 319, -1, 321, 322, 323, 324, -1, -1, -1,
	328, 258, 259, -1, 261, -1, 263, 264, 265, -1,
	267, 268, 269, -1, -1, 343, 344, 274, 275, -1,
	-1, -1, -1, -1, 281, 282, 283, 284, -1, -1,
	287, -1, 289, -1, -1, -1, -1, 294, -1, 296,
	297, 298, 299, -1, -1, -1, 303, 304, 305, 306,
	307, -1, 309, -1, -1, -1, 313, -1, 315, -1,
	317, 318, 319, -1, 321, 322, 323, 324, -1, -1,
	-1, 328, 258, 259, -1, 261, -1, 263, 264, 265,
	-1, 267, 268, 269, -1, -1, 343, 344, 274, 275,
	-1, -1, -1, -1, -1, 281, 282, 283, 284, -1,
	-1, 287, -1, 289, -1, -1, -1, -1, 294, -1,
	296, 297, 298, 299, -1, -1, -1, 303, 304, 305,
	306, 307, -1, 309, -1, -1, -1, 313, -1, 315,
	-1, 317, 318, 319, -1, 321, 322, 323, 324, -1,
	-1, -1, 328, 258, 259, -1, 261, -1, 263, 264,
	265, -1, 267, 268, 269, -1, -1, 343, 344, 274,
	275, -1, -1, -1, -1, -1, 281, 282, 283, 284,
	-1, -1, 287, -1, 289, -1, -1, -1, -1, 294,
	-1, 296, 297, 298, 299, -1, -1, -1, 303, 304,
	305, 306, 307, -1, 309, -1, -1, -1, 313, -1,
	315, -1, 317, 318, 319, -1, 321, 322, 323, 324,
	-1, -1, -1, 328, 258, 259, -1, 261, -1, 263,
	264, 265, -1, 267, 268, 269, -1, -1, 343, 344,
	274, 275, -1, -1, -1, -1, -1, 281, 282, 283,
	284, -1, -1, 287, -1, 289, -1, -1, -1, -1,
	294, -1, 296, 297, 298, 299, -1, -1, -1, 303,
	304, 305, 306, 307, -1, 309, -1, -1, -1, 313,
	-1, 315, -1, 317, 318, 319, -1, 321, 322, 323,
	324, 258, 259, -1, 328, -1, 263, 264, 265, -1,
	-1, 268, 269, -1, -1, -1, -1, -1, -1, 343,
	344, -1, -1, -1, -1, 282, -1, 284, -1, -1,
	287, -1, 289, -1, -1, -1, -1, 294, -1, 296,
	297, 298, 299, 300, -1, -1, 303, 304, 305, 306,
	307, -1, -1, -1, -1, -1, -1, -1, 315, -1,
	317, -1, -1, -1, 321, 322, 323, 324, 258, 259,
	-1, 328, -1, 263, 264, 265, -1, 334, 268, 269,
	-1, -1, -1, -1, -1, -1, 343, 344, -1, -1,
	-1, -1, 282, -1, 284, -1, -1, 287, -1, 289,
	-1, -1, -1, -1, 294, -1, 296, 297, 298, 299,
	300, -1, -1, 303, 304, 305, 306, 307, -1, -1,
	-1, -1, -1, -1, -1, 315, -1, 317, -1, -1,
	-1, 321, 322, 323, 324, -1, -1, -1, 328, -1,
	-1, 259, -1, 261, 334, 263, 264, 265, -1, 267,
	268, 269, -1, 343, 344, -1, 274, 275, -1, -1,
	-1, -1, -1, 281, 282, 283, 284, -1, -1, 287,
	-1, 289, -1, -1, -1, -1, 294, -1, 296, 297,
	298, 299, 300, -1, -1, 303, 304, 305, 306, 307,
	-1, 309, -1, -1, -1, 313, -1, 315, -1, 317,
	318, 319, -1, 321, 322, 323, 324, 259, -1, -1,
	328, 263, 264, 265, -1, -1, 268, -1, -1, -1,
	-1, -1, -1, -1, -1, 343, 344, -1, -1, -1,
	282, -1, 284, -1, -1, 287, 288, 289, -1, -1,
	-1, 293, 294, -1, 296, 297, 298, 299, -1, 301,
	-1, 303, 304, 305, 306, 307, -1, -1, 259, -1,
	-1, -1, 263, 264, 265, 317, -1, 268, -1, 321,
	322, 323, 324, 325, -1, -1, 328, -1, -1, -1,
	-1, 282, -1, 284, -1, -1, 287, -1, 289, 341,
	-1, 343, 344, 294, 295, 296, 297, 298, 299, -1,
	-1, 302, 303, 304, 305, 306, 307, -1, -1, 259,
	-1, -1, -1, 263, 264, 265, 317, -1, 268, -1,
	321, 322, 323, 324, -1, -1, -1, 328, -1, -1,
	-1, -1, 282, -1, 284, -1, -1, 287, -1, 289,
	-1, -1, 343, 344, 294, 295, 296, 297, 298, 299,
	-1, -1, -1, 303, 304, 305, 306, 307, -1, -1,
	259, -1, -1, -1, 263, 264, 265, 317, -1, 268,
	-1, 321, 322, 323, 324, -1, -1, -1, 328, -1,
	-1, -1, -1, 282, -1, 284, -1, -1, 287, -1,
	289, -1, -1, 343, 344, 294, -1, 296, 297, 298,
	299, 300, -1, -1, 303, 304, 305, 306, 307, -1,
	-1, 259, -1, -1, -1, 263, 264, 265, 317, -1,
	268, -1, 321, 322, 323, 324, -1, -1, -1, 328,
	-1, -1, -1, -1, 282, -1, 284, -1, -1, 287,
	-1, 289, -1, -1, 343, 344, 294, -1, 296, 297,
	298, 299, -1, -1, 302, 303, 304, 305, 306, 307,
	-1, -1, 259, -1, -1, -1, 263, 264, 265, 317,
	-1, 268, -1, 321, 322, 323, 324, -1, -1, -1,
	328, -1, -1, -1, -1, 282, -1, 284, -1, -1,
	287, -1, 289, -1, -1, 343, 344, 294, -1, 296,
	297, 298, 299, -1, -1, -1, 303, 304, 305, 306,
	307, -1, -1, 259, -1, -1, -1, 263, 264, 265,
	317, -1, 268, -1, 321, 322, 323, 324, -1, -1,
	-1, 328, -1, -1, -1, -1, 282, -1, 284, -1,
	-1, 287, -1, 289, -1, -1, 343, 344, 294, -1,
	296, 297, 298, 299, -1, -1, -1, 303, 304, 305,
	306, 307, -1, -1, -1, -1, -1, -1, -1, -1,
	-1, 317, -1, -1, -1, 321, 322, 323, 324, 258,
	259, -1, 328, -1, 263, 264, 265, -1, -1, 268,
	-1, -1, -1, -1, 273, -1, -1, 343, 344, -1,
	-1, -1, -1, 282, -1, 284, -1, -1, -1, -1,
	289, -1, -1, -1, -1, 294, -1, -1, 297, -1,
	-1, -1, -1, -1, 303, 304, 305, 306, 307, -1,
	259, -1, -1, -1, 263, 264, 265, -1, 317, 268,
	-1, -1, 321, 322, 323, 324, -1, -1, -1, -1,
	-1, -1, -1, 282, -1, 284, -1, 286, -1, -1,
	289, -1, 291, -1, -1, 294, -1, -1, 297, -1,
	-1, -1, -1, -1, 303, 304, 305, 306, 307, -1,
	-1, -1, -1, -1, -1, -1, -1, -1, 317, -1,
	-1, -1, 321, 322, 323, 324, 259, -1, -1, -1,
	263, 264, 265, -1, -1, 268, -1, -1, 271, 272,
	-1, -1, -1, -1, -1, -1, -1, -1, -1, 282,
	-1, 284, -1, -1, -1, -1, 289, -1, -1, -1,
	-1, 294, -1, -1, 297, -1, -1, -1, -1, -1,
	303, 304, 305, 306, 307, -1, 259, -1, -1, -1,
	263, 264, 265, -1, 317, 268, -1, -1, 321, 322,
	323, 324, -1, -1, -1, -1, -1, -1, -1, 282,
	-1, 284, -1, 286, -1, -1, 289, -1, 291, -1,
	-1, 294, -1, -1, 297, -1, -1, -1, -1, -1,
	303, 304, 305, 306, 307, -1, -1, -1, -1, -1,
	-1, -1, -1, -1, 317, -1, -1, -1, 321, 322,
	323, 324, 259, -1, -1, -1, 263, 264, 265, -1,
	-1, 268, -1, -1, -1, -1, 273, -1, -1, -1,
	-1, -1, -1, -1, -1, 282, -1, 284, -1, -1,
	-1, -1, 289, -1, -1, -1, -1, 294, -1, -1,
	297, -1, -1, -1, -1, -1, 303, 304, 305, 306,
	307, -1, 259, -1, -1, -1, 263, 264, 265, -1,
	317, 268, -1, -1, 321, 322, 323, 324, -1, -1,
	-1, -1, -1, -1, -1, 282, -1, 284, -1, -1,
	-1, -1, 289, -1, -1, -1, -1, 294, -1, -1,
	297, -1, -1, -1, -1, -1, 303, 304, 305, 306,
	307, -1, 259, -1, -1, -1, 263, 264, 265, -1,
	317, 268, -1, -1, 321, 322, 323, 324, -1, -1,
	-1, -1, -1, -1, -1, 282, -1, 284, -1, -1,
	-1, -1, 289, -1, -1, -1, -1, 294, -1, -1,
	297, -1, -1, -1, -1, -1, 303, 304, 305, 306,
	307, -1, 259, -1, -1, -1, 263, 264, 265, -1,
	317, 268, -1, -1, 321, 322, 323, 324, -1, -1,
	-1, -1, -1, -1, -1, 282, -1, 284, -1, -1,
	-1, -1, 289, -1, -1, -1, -1, 294, -1, -1,
	297, -1, -1, -1, -1, -1, 303, 304, 305, 306,
	307, -1, -1, -1, -1, -1, -1, -1, -1, -1,
	317, -1, -1, -1, 321, 322, 323, 324,
};

#define YYFINAL 2
#ifndef YYDEBUG
#define YYDEBUG 0
#endif
#define YYMAXTOKEN 344
#if YYDEBUG
char *yyname[] = {
	"end-of-file", 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
	    0, 0, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
	    0, 0, 0, 0, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
	    0, 0, 0, 0, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
	    0, 0, 0, 0, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
	    0, 0, 0, 0, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0,
	    0, 0, 0, 0, 0, 0, 0, 0, 0,
	0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, 0, "ABSENT", "ACTION",
	    "ANY",
	"APPLICATION", "BAR", "BGIN", "BIT", "BITSTRING", "BOOLEAN", "BY", "CCE", "CHOICE",
	"COMMA", "COMPONENT", "COMPONENTS", "COMPONENTSOF", "CONTROL", "DECODER", "DEFAULT",
	"DEFINED", "DEFINITIONS", "DOT", "DOTDOT", "DOTDOTDOT", "ENCODER", "ENCRYPTED", "END",
	"ENUMERATED", "EXPORTS", "EXPLICIT", "L_FALSE", "FROM", "ID", "IDENTIFIER", "IMPLICIT",
	"IMPORTS", "INCLUDES", "INTEGER", "LANGLE", "LBRACE", "LBRACKET", "LITNUMBER",
	"LITSTRING", "LPAREN", "MIN", "MAX", "NAME", "NIL", "OBJECT", "OCTET", "OCTETSTRING",
	"OF", "OPTIONAL", "PARAMETERTYPE", "PREFIXES", "PRESENT", "PRINTER", "PRIVATE",
	"RBRACE", "RBRACKET", "REAL", "RPAREN", "SECTIONS", "SEMICOLON", "SEQUENCE",
	"SEQUENCEOF", "SET", "SETOF", "SIZE", "STRING", "TAGS", "L_TRUE", "UNIVERSAL", "VALA",
	"VALB", "VALI", "VALS", "VALP", "VALO", "VALOID", "VALR", "VALQ", "VALX", "VLENGTH",
	"WITH", "SCTRL", "PLUSINFINITY", "MINUSINFINITY",
};
char *yyrule[] = {
	"$accept : ModuleDefinition",
	"$$1 :",
	"$$2 :",
	"ModuleDefinition : ModuleIdentifier DEFINITIONS TagDefault CCE $$1 ModuleActions ModulePrefixes BGIN ModuleBody END $$2 ModuleActions",
	"TagDefault : EXPLICIT TAGS",
	"TagDefault : IMPLICIT TAGS",
	"TagDefault : empty",
	"ModuleIdentifier : ID AssignedIdentifier",
	"AssignedIdentifier : ObjectIdentifierValue",
	"AssignedIdentifier : empty",
	"ModuleActions : ACTION",
	"ModuleActions : empty",
	"ModulePrefixes : PREFIXES String String String",
	"ModulePrefixes : empty",
	"ModuleBody : Exports Imports AssignmentList",
	"$$3 :",
	"Exports : EXPORTS $$3 SymbolsExported SEMICOLON",
	"Exports : empty",
	"SymbolsExported : SymbolList",
	"SymbolsExported : empty",
	"$$4 :",
	"Imports : IMPORTS $$4 SymbolsImported SEMICOLON",
	"Imports : empty",
	"SymbolsImported : SymbolsFromModuleList",
	"SymbolsImported : empty",
	"SymbolsFromModuleList : SymbolsFromModuleList SymbolsFromModule",
	"SymbolsFromModuleList : SymbolsFromModule",
	"SymbolsFromModule : SymbolList FROM ModuleIdentifier",
	"SymbolList : SymbolList COMMA Symbol",
	"SymbolList : Symbol",
	"Symbol : ID",
	"Symbol : NAME",
	"AssignmentList : AssignmentList Section Assignment",
	"AssignmentList : empty",
	"Section : ENCODER String",
	"Section : DECODER String",
	"Section : PRINTER String",
	"Section : SECTIONS String String String",
	"Section : empty",
	"String : ID",
	"String : NAME",
	"Assignment : Typeassignment",
	"Assignment : Valueassignment",
	"Typeassignment : ID ParameterType Action CCE Action Type",
	"Type : BuiltinType Action",
	"Type : DefinedType Action",
	"Type : SubType Action",
	"Action : ACTION",
	"Action : empty",
	"Control : CONTROL",
	"Control : empty",
	"ParameterType : PARAMETERTYPE",
	"ParameterType : empty",
	"BuiltinType : BOOLEAN PassBool",
	"BuiltinType : INTEGER PassInt NNlist",
	"BuiltinType : ENUMERATED PassInt LBRACE NamedNumberList RBRACE",
	"BuiltinType : Bitstring PassBit NNlist",
	"BuiltinType : Octetstring PassString",
	"BuiltinType : NIL",
	"BuiltinType : SEQUENCE Sctrl PassAny",
	"BuiltinType : SequenceOf Sctrl Action Control Type",
	"BuiltinType : SEQUENCE Sctrl Action LBRACE ElementTypes RBRACE",
	"BuiltinType : SET Sctrl PassAny",
	"BuiltinType : SetOf Sctrl Action Control Type",
	"BuiltinType : SET Sctrl Action LBRACE MemberTypes RBRACE",
	"BuiltinType : Tag Action IMPLICIT Type",
	"BuiltinType : Tag Action EXPLICIT Type",
	"BuiltinType : Tag Action Type",
	"BuiltinType : CHOICE Sctrl Action Control LBRACE AlternativeTypeList RBRACE",
	"BuiltinType : NAME LANGLE Type",
	"BuiltinType : AnyType PassAny",
	"BuiltinType : OBJECT IDENTIFIER PassOid",
	"BuiltinType : ENCRYPTED Type",
	"BuiltinType : REAL PassReal",
	"NNlist : LBRACE NamedNumberList RBRACE",
	"NNlist : empty",
	"DefinedType : ID PassValue ValParameter",
	"DefinedType : ID DOT ID PassValue ValParameter",
	"PassValue : VALA",
	"PassValue : VALB",
	"PassValue : VALI",
	"PassValue : VALX VLENGTH",
	"PassValue : VALOID",
	"PassValue : PassString",
	"AnyType : ANY",
	"AnyType : ANY DEFINED BY NAME",
	"PassOid : VALOID",
	"PassOid : empty",
	"PassAny : VALA",
	"PassAny : empty",
	"PassBool : VALB",
	"PassBool : empty",
	"PassInt : VALI",
	"PassInt : empty",
	"PassBit : VALX VLENGTH",
	"PassBit : NullPass",
	"PassString : VALS",
	"PassString : VALO VLENGTH",
	"PassString : VALQ",
	"PassString : NullPass",
	"PassReal : VALR",
	"PassReal : empty",
	"NullPass : empty",
	"ValParameter : VALP",
	"ValParameter : empty",
	"NamedNumberList : NamedNumber",
	"NamedNumberList : NamedNumberList COMMA NamedNumber",
	"NamedNumber : NAME LPAREN NumericValue RPAREN Action",
	"NumericValue : LITNUMBER",
	"NumericValue : DefinedValue",
	"ElementTypes : OptionalTypeList",
	"ElementTypes : empty",
	"MemberTypes : OptionalTypeList",
	"MemberTypes : empty",
	"OptionalTypeList : OptionalType",
	"OptionalTypeList : OptionalTypeList COMMA OptionalType",
	"OptionalType : NamedType",
	"OptionalType : NamedType OPTIONAL Control",
	"OptionalType : NamedType DEFAULT Value Control",
	"OptionalType : ComponentsOf",
	"OptionalType : NAME ComponentsOf",
	"NamedType : NAME Action Type",
	"NamedType : Type",
	"ComponentsOf : Components Type",
	"AlternativeTypeList : NamedType",
	"AlternativeTypeList : AlternativeTypeList COMMA NamedType",
	"Tag : LBRACKET Class NumericValue RBRACKET",
	"Class : UNIVERSAL",
	"Class : APPLICATION",
	"Class : PRIVATE",
	"Class : empty",
	"Valueassignment : NAME Type CCE Value",
	"Value : BuiltinValue",
	"Value : DefinedValue",
	"BuiltinValue : L_TRUE",
	"BuiltinValue : L_FALSE",
	"BuiltinValue : LITNUMBER",
	"BuiltinValue : LBRACE ID IdentifierList RBRACE",
	"BuiltinValue : LITSTRING",
	"BuiltinValue : NIL",
	"BuiltinValue : LBRACE Values RBRACE",
	"BuiltinValue : NAME Value",
	"BuiltinValue : Type Value",
	"BuiltinValue : RealValue",
	"RealValue : NumericRealValue",
	"RealValue : SpecialRealValue",
	"SpecialRealValue : PLUSINFINITY",
	"SpecialRealValue : MINUSINFINITY",
	"NumericRealValue : LBRACE LITNUMBER COMMA LITNUMBER COMMA LITNUMBER RBRACE",
	"DefinedValue : ID",
	"DefinedValue : NAME",
	"DefinedValue : ID DOT ID",
	"IdentifierList : IdentifierList COMMA ID",
	"IdentifierList : empty",
	"Values : NamedValueList",
	"Values : empty",
	"NamedValueList : NamedValue",
	"NamedValueList : NamedValueList COMMA NamedValue",
	"NamedValue : Value",
	"empty :",
	"Octetstring : OCTET STRING",
	"Octetstring : OCTETSTRING",
	"Bitstring : BITSTRING",
	"Bitstring : BIT STRING",
	"SequenceOf : SEQUENCEOF",
	"SequenceOf : SEQUENCE OF",
	"SetOf : SETOF",
	"SetOf : SET OF",
	"Components : COMPONENTSOF",
	"Components : COMPONENTS OF",
	"ObjectIdentifierValue : LBRACE ObjIdComponentList RBRACE",
	"ObjIdComponentList : ObjIdComponent",
	"ObjIdComponentList : ObjIdComponentList ObjIdComponent",
	"ObjIdComponent : NumberForm",
	"ObjIdComponent : NameAndNumberForm",
	"NumberForm : LITNUMBER",
	"NumberForm : DefinedValue",
	"NameAndNumberForm : NAME LPAREN NumberForm RPAREN",
	"SubType : Type SubtypeSpec",
	"SubType : SET SizeConstraint OF Sctrl Action Control Type",
	"SubType : SEQUENCE SizeConstraint OF Sctrl Action Control Type",
	"SubtypeSpec : LPAREN SubtypeAlternative SubtypeAlternativeList RPAREN",
	"SubtypeAlternative : SubtypeValueSet",
	"SubtypeAlternative : SubtypeConstraint",
	"SubtypeAlternativeList : BAR SubtypeAlternative SubtypeAlternativeList",
	"SubtypeAlternativeList : empty",
	"SubtypeValueSet : Value",
	"SubtypeValueSet : ContainedSubType",
	"SubtypeValueSet : ValueRange",
	"SubtypeValueSet : PermittedAlphabet",
	"SubtypeConstraint : SizeConstraint",
	"SubtypeConstraint : InnerTypeConstraint",
	"ContainedSubType : INCLUDES Type",
	"ValueRange : LowerEndPoint DOTDOT UpperEndpoint",
	"LowerEndPoint : LowerEndValue",
	"LowerEndPoint : LowerEndValue LANGLE",
	"UpperEndpoint : UpperEndValue",
	"UpperEndpoint : LANGLE UpperEndValue",
	"LowerEndValue : Value",
	"LowerEndValue : MIN",
	"UpperEndValue : Value",
	"UpperEndValue : MAX",
	"SizeConstraint : SIZE SubtypeSpec",
	"PermittedAlphabet : FROM SubtypeSpec",
	"InnerTypeConstraint : WITH COMPONENT SingleTypeConstraint",
	"InnerTypeConstraint : WITH COMPONENTS MultipleTypeConstraints",
	"SingleTypeConstraint : SubtypeSpec",
	"MultipleTypeConstraints : FullSpecification",
	"MultipleTypeConstraints : PartialSpecification",
	"FullSpecification : LBRACE TypeConstraints RBRACE",
	"PartialSpecification : LBRACE DOTDOTDOT COMMA TypeConstraints RBRACE",
	"TypeConstraints : NamedConstraint",
	"TypeConstraints : NamedConstraint COMMA TypeConstraints",
	"NamedConstraint : NAME Constraint",
	"NamedConstraint : Constraint",
	"Constraint : ValueConstraint",
	"Constraint : PresenceConstraint",
	"Constraint : empty",
	"ValueConstraint : SubtypeSpec",
	"PresenceConstraint : PRESENT",
	"PresenceConstraint : ABSENT",
	"Sctrl : SCTRL",
	"Sctrl : empty",
};
#endif
#define yyclearin (yychar=(-1))
#define yyerrok (yyerrflag=0)
#ifdef YYSTACKSIZE
#ifndef YYMAXDEPTH
#define YYMAXDEPTH YYSTACKSIZE
#endif
#else
#ifdef YYMAXDEPTH
#define YYSTACKSIZE YYMAXDEPTH
#else
#define YYSTACKSIZE 500
#define YYMAXDEPTH 500
#endif
#endif
int yydebug;
int yynerrs;
int yyerrflag;
int yychar;
short *yyssp;
YYSTYPE *yyvsp;
YYSTYPE yyval;
YYSTYPE yylval;
short yyss[YYSTACKSIZE];
YYSTYPE yyvs[YYSTACKSIZE];

#define yystacksize YYSTACKSIZE
#line 1070 "yacc.y"

#ifdef	HPUX
#define	uchar	Uchar
#endif
#include "lex.c"
#line 1245 "y.tab.c"
#define YYABORT goto yyabort
#define YYACCEPT goto yyaccept
#define YYERROR goto yyerrlab
int
yyparse()
{
	register int yym, yyn, yystate;

#if YYDEBUG
	register char *yys;
	extern char *getenv();

	if (yys = getenv("YYDEBUG")) {
		yyn = *yys;
		if (yyn >= '0' && yyn <= '9')
			yydebug = yyn - '0';
	}
#endif

	yynerrs = 0;
	yyerrflag = 0;
	yychar = (-1);

	yyssp = yyss;
	yyvsp = yyvs;
	*yyssp = yystate = 0;

      yyloop:
	if (yyn = yydefred[yystate])
		goto yyreduce;
	if (yychar < 0) {
		if ((yychar = yylex()) < 0)
			yychar = 0;
#if YYDEBUG
		if (yydebug) {
			yys = 0;
			if (yychar <= YYMAXTOKEN)
				yys = yyname[yychar];
			if (!yys)
				yys = "illegal-symbol";
			printf("yydebug: state %d, reading %d (%s)\n", yystate, yychar, yys);
		}
#endif
	}
	if ((yyn = yysindex[yystate]) && (yyn += yychar) >= 0 &&
	    yyn <= YYTABLESIZE && yycheck[yyn] == yychar) {
#if YYDEBUG
		if (yydebug)
			printf("yydebug: state %d, shifting to state %d\n", yystate, yytable[yyn]);
#endif
		if (yyssp >= yyss + yystacksize - 1) {
			goto yyoverflow;
		}
		*++yyssp = yystate = yytable[yyn];
		*++yyvsp = yylval;
		yychar = (-1);
		if (yyerrflag > 0)
			--yyerrflag;
		goto yyloop;
	}
	if ((yyn = yyrindex[yystate]) && (yyn += yychar) >= 0 &&
	    yyn <= YYTABLESIZE && yycheck[yyn] == yychar) {
		yyn = yytable[yyn];
		goto yyreduce;
	}
	if (yyerrflag)
		goto yyinrecovery;
#ifdef lint
	goto yynewerror;
#endif
      yynewerror:
	yyerror("syntax error");
#ifdef lint
	goto yyerrlab;
#endif
      yyerrlab:
	++yynerrs;
      yyinrecovery:
	if (yyerrflag < 3) {
		yyerrflag = 3;
		for (;;) {
			if ((yyn = yysindex[*yyssp]) && (yyn += YYERRCODE) >= 0 &&
			    yyn <= YYTABLESIZE && yycheck[yyn] == YYERRCODE) {
#if YYDEBUG
				if (yydebug)
					printf("yydebug: state %d, error recovery shifting\
 to state %d\n", *yyssp, yytable[yyn]);
#endif
				if (yyssp >= yyss + yystacksize - 1) {
					goto yyoverflow;
				}
				*++yyssp = yystate = yytable[yyn];
				*++yyvsp = yylval;
				goto yyloop;
			} else {
#if YYDEBUG
				if (yydebug)
					printf("yydebug: error recovery discarding state %d\n",
					       *yyssp);
#endif
				if (yyssp <= yyss)
					goto yyabort;
				--yyssp;
				--yyvsp;
			}
		}
	} else {
		if (yychar == 0)
			goto yyabort;
#if YYDEBUG
		if (yydebug) {
			yys = 0;
			if (yychar <= YYMAXTOKEN)
				yys = yyname[yychar];
			if (!yys)
				yys = "illegal-symbol";
			printf("yydebug: state %d, error recovery discards token %d (%s)\n",
			       yystate, yychar, yys);
		}
#endif
		yychar = (-1);
		goto yyloop;
	}
      yyreduce:
#if YYDEBUG
	if (yydebug)
		printf("yydebug: state %d, reducing by rule %d (%s)\n", yystate, yyn, yyrule[yyn]);
#endif
	yym = yylen[yyn];
	yyval = yyvsp[1 - yym];
	switch (yyn) {
	case 1:
#line 174 "yacc.y"
	{
		mymodule = yyvsp[-3].yy_string;
		mymoduleid = modid;
		pass1();
	}
		break;
	case 2:
#line 180 "yacc.y"
	{
		pass2();
		final_actions++;
	}
		break;
	case 4:
#line 184 "yacc.y"
	{
		tagdefault = 0;
		tagcontrol = TAG_EXPLICIT;
	}
		break;
	case 5:
#line 188 "yacc.y"
	{
		tagdefault = YP_IMPLICIT;
		tagcontrol = TAG_IMPLICIT;
	}
		break;
	case 6:
#line 192 "yacc.y"
	{
		tagdefault = 0;
		tagcontrol = TAG_UNKNOWN;
	}
		break;
	case 7:
#line 198 "yacc.y"
	{
		yyval.yy_string = yyvsp[-1].yy_string;
	}
		break;
	case 8:
#line 201 "yacc.y"
	{
		modid = yyvsp[0].yy_oid;
	}
		break;
	case 10:
#line 205 "yacc.y"
	{
		if (bflag) {
			if (final_actions)
				init_new_file();
			else {
				module_actions = yyvsp[0].yy_action->ya_text;
				free_action(yyvsp[0].yy_action);
				break;
			}
		}
		if (!dflag) {
			if (Cflag > 0) {
				if (!Pflag && *sysin)
					printf("# line %d \"%s\"\n",
					       yyvsp[0].yy_action->ya_lineno, sysin);
				fputs(yyvsp[0].yy_action->ya_text, stdout);
			} else {
				printf("%%{\n#include \"%s-types.h\"\n", mymodule);
				printf("%s%%}\n", yyvsp[0].yy_action->ya_text);
				Cflag = -1;
			}
		}
		free_action(yyvsp[0].yy_action);
		if (bflag)
			end_file();
	}
		break;
	case 12:
#line 237 "yacc.y"
	{
		yyencdflt = yyvsp[-2].yy_string;
		yydecdflt = yyvsp[-1].yy_string;
		yyprfdflt = yyvsp[0].yy_string;
	}
		break;
	case 15:
#line 247 "yacc.y"
	{
		listtype = TBL_EXPORT;
		doexternals = 0;
		yyporting = 1;
	}
		break;
	case 16:
#line 249 "yacc.y"
	{
		yyporting = 0;
	}
		break;
	case 20:
#line 259 "yacc.y"
	{
		listtype = TBL_IMPORT;
		yyporting = 1;
	}
		break;
	case 21:
#line 260 "yacc.y"
	{
		yyporting = 0;
	}
		break;
	case 27:
#line 276 "yacc.y"
	{
		addtableref(yyvsp[0].yy_string, modid, listtype);
	}
		break;
	case 28:
#line 281 "yacc.y"
	{
		addtable(yyvsp[0].yy_string, listtype);
	}
		break;
	case 29:
#line 282 "yacc.y"
	{
		addtable(yyvsp[0].yy_string, listtype);
	}
		break;
	case 34:
#line 294 "yacc.y"
	{
		yysection = YP_ENCODER;
		yyencpref = yyvsp[0].yy_string;
		yyprint(NULLCP, 0, 1);
	}
		break;
	case 35:
#line 297 "yacc.y"
	{
		yysection = YP_DECODER;
		yydecpref = yyvsp[0].yy_string;
		yyprint(NULLCP, 0, 1);
	}
		break;
	case 36:
#line 300 "yacc.y"
	{
		yysection = YP_PRINTER;
		yyprfpref = yyvsp[0].yy_string;
		yyprint(NULLCP, 0, 1);
	}
		break;
	case 37:
#line 303 "yacc.y"
	{
		yysection = NULL;
		if (strcmp(yyencpref = yyvsp[-2].yy_string, "none"))
			yysection |= YP_ENCODER;
		if (strcmp(yydecpref = yyvsp[-1].yy_string, "none"))
			yysection |= YP_DECODER;
		if (strcmp(yyprfpref = yyvsp[0].yy_string, "none"))
			yysection |= YP_PRINTER;
		yyprint(NULLCP, 0, 1);
	}
		break;
	case 39:
#line 316 "yacc.y"
	{
		yyval.yy_string = yyvsp[0].yy_string;
	}
		break;
	case 40:
#line 317 "yacc.y"
	{
		yyval.yy_string = yyvsp[0].yy_string;
	}
		break;
	case 43:
#line 326 "yacc.y"
	{
		if (yyvsp[-4].yy_string)
			yyvsp[0].yy_type->yp_param_type = yyvsp[-4].yy_string;
		if (yyvsp[-3].yy_action) {
			yyvsp[0].yy_type->yp_action0 = yyvsp[-3].yy_action->ya_text;
			yyvsp[0].yy_type->yp_act0_lineno = yyvsp[-3].yy_action->ya_lineno;
			free_action(yyvsp[-3].yy_action);
		}
		if (yyvsp[-1].yy_action) {
			if (yyvsp[0].yy_type->yp_action05 == NULLCP) {
				yyvsp[0].yy_type->yp_action05 = yyvsp[-1].yy_action->ya_text;
				yyvsp[0].yy_type->yp_act05_lineno = yyvsp[-1].yy_action->ya_lineno;
				free_action(yyvsp[-1].yy_action);
			} else
				yyerror("too many preliminary actions associated with type");
		}
		pass1_type(yyencpref, yydecpref, yyprfpref,
			   mymodule, yyvsp[-5].yy_string, yyvsp[0].yy_type);
	}
		break;
	case 44:
#line 347 "yacc.y"
	{
		yyval.yy_type = yyvsp[-1].yy_type;
		yyval.yy_type->yp_direction = yysection;
		if (yyvsp[0].yy_action) {
			yyval.yy_type->yp_action2 = yyvsp[0].yy_action->ya_text;
			yyval.yy_type->yp_act2_lineno = yyvsp[0].yy_action->ya_lineno;
			free_action(yyvsp[0].yy_action);
		}
	}
		break;
	case 45:
#line 356 "yacc.y"
	{
		yyval.yy_type = yyvsp[-1].yy_type;
		yyval.yy_type->yp_direction = yysection;
		if (yyvsp[0].yy_action) {
			yyval.yy_type->yp_action2 = yyvsp[0].yy_action->ya_text;
			yyval.yy_type->yp_act2_lineno = yyvsp[0].yy_action->ya_lineno;
			free_action(yyvsp[0].yy_action);
		}
	}
		break;
	case 46:
#line 365 "yacc.y"
	{
		yyval.yy_type = yyvsp[-1].yy_type;
		yyval.yy_type->yp_direction = yysection;
		if (yyvsp[0].yy_action) {
			yyval.yy_type->yp_action2 = yyvsp[0].yy_action->ya_text;
			yyval.yy_type->yp_act2_lineno = yyvsp[0].yy_action->ya_lineno;
			free_action(yyvsp[0].yy_action);
		}
	}
		break;
	case 48:
#line 377 "yacc.y"
	{
		yyval.yy_action = NULLYA;
	}
		break;
	case 50:
#line 381 "yacc.y"
	{
		yyval.yy_string = NULLCP;
	}
		break;
	case 52:
#line 385 "yacc.y"
	{
		yyval.yy_string = NULLCP;
	}
		break;
	case 53:
#line 388 "yacc.y"
	{
		yyval.yy_type = new_type(YP_BOOL);
		yyval.yy_type->yp_intexp = yyvsp[0].yy_string;
	}
		break;
	case 54:
#line 392 "yacc.y"
	{
		yyval.yy_type = new_type(yyvsp[0].yy_value ? YP_INTLIST : YP_INT);
		yyval.yy_type->yp_intexp = yyvsp[-1].yy_string;
		if (yyvsp[0].yy_value)
			yyval.yy_type->yp_value = yyvsp[0].yy_value;
	}
		break;
	case 55:
#line 398 "yacc.y"
	{
		yyval.yy_type = new_type(YP_ENUMLIST);
		yyval.yy_type->yp_intexp = yyvsp[-3].yy_string;
		yyval.yy_type->yp_value = yyvsp[-1].yy_value;
	}
		break;
	case 56:
#line 404 "yacc.y"
	{
		yyval.yy_type = yyvsp[-1].yy_type;
		yyval.yy_type->yp_code = yyvsp[0].yy_value ? YP_BITLIST : YP_BIT;
		if (yyvsp[0].yy_value)
			yyval.yy_type->yp_value = yyvsp[0].yy_value;
	}
		break;
	case 57:
#line 410 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
		yyval.yy_type->yp_code = YP_OCT;
	}
		break;
	case 58:
#line 414 "yacc.y"
	{
		yyval.yy_type = new_type(YP_NULL);
	}
		break;
	case 59:
#line 415 "yacc.y"
	{
		yyval.yy_type = new_type(YP_SEQ);
		yyval.yy_type->yp_strexp = yyvsp[0].yy_string;
	}
		break;
	case 60:
#line 419 "yacc.y"
	{
		yyval.yy_type = new_type(YP_SEQTYPE);
		yyval.yy_type->yp_type = yyvsp[0].yy_type;
		if (yyvsp[-3].yy_sctrl) {
			yyval.yy_type->yp_structname = yyvsp[-3].yy_sctrl->ys_structname;
			yyval.yy_type->yp_ptrname = yyvsp[-3].yy_sctrl->ys_ptrname;
			free_ys(yyvsp[-3].yy_sctrl);
		}
		if (yyvsp[-1].yy_string) {
			yyval.yy_type->yp_control = yyvsp[-1].yy_string;
			yyval.yy_type->yp_flags |= YP_CONTROLLED;
		}
		if (yyvsp[-2].yy_action) {
			yyval.yy_type->yp_action3 = yyvsp[-2].yy_action->ya_text;
			yyval.yy_type->yp_act3_lineno = yyvsp[-2].yy_action->ya_lineno;
			free_action(yyvsp[-2].yy_action);
		}
	}
		break;
	case 61:
#line 437 "yacc.y"
	{
		yyval.yy_type = new_type(YP_SEQLIST);
		yyval.yy_type->yp_type = yyvsp[-1].yy_type;
		if (yyvsp[-4].yy_sctrl) {
			yyval.yy_type->yp_structname = yyvsp[-4].yy_sctrl->ys_structname;
			yyval.yy_type->yp_ptrname = yyvsp[-4].yy_sctrl->ys_ptrname;
			free_ys(yyvsp[-4].yy_sctrl);
		}
		if (yyvsp[-3].yy_action && yyval.yy_type->yp_action1 == NULLCP) {
			yyval.yy_type->yp_action1 = yyvsp[-3].yy_action->ya_text;
			yyval.yy_type->yp_act1_lineno = yyvsp[-3].yy_action->ya_lineno;
			free_action(yyvsp[-3].yy_action);
		} else if (yyvsp[-3].yy_action)
			yyerror("too many actions associated with SEQUENCE");
	}
		break;
	case 62:
#line 453 "yacc.y"
	{
		yyval.yy_type = new_type(YP_SET);
		yyval.yy_type->yp_strexp = yyvsp[0].yy_string;
	}
		break;
	case 63:
#line 457 "yacc.y"
	{
		yyval.yy_type = new_type(YP_SETTYPE);
		yyval.yy_type->yp_type = yyvsp[0].yy_type;
		if (yyvsp[-3].yy_sctrl) {
			yyval.yy_type->yp_structname = yyvsp[-3].yy_sctrl->ys_structname;
			yyval.yy_type->yp_ptrname = yyvsp[-3].yy_sctrl->ys_ptrname;
			free_ys(yyvsp[-3].yy_sctrl);
		}
		if (yyvsp[-1].yy_string) {
			yyval.yy_type->yp_control = yyvsp[-1].yy_string;
			yyval.yy_type->yp_flags |= YP_CONTROLLED;
		}
		if (yyvsp[-2].yy_action) {
			yyval.yy_type->yp_action3 = yyvsp[-2].yy_action->ya_text;
			yyval.yy_type->yp_act3_lineno = yyvsp[-2].yy_action->ya_lineno;
			free_action(yyvsp[-2].yy_action);
		}
	}
		break;
	case 64:
#line 476 "yacc.y"
	{
		yyval.yy_type = new_type(YP_SETLIST);
		yyval.yy_type->yp_type = yyvsp[-1].yy_type;
		if (yyvsp[-4].yy_sctrl) {
			yyval.yy_type->yp_structname = yyvsp[-4].yy_sctrl->ys_structname;
			yyval.yy_type->yp_ptrname = yyvsp[-4].yy_sctrl->ys_ptrname;
			free_ys(yyvsp[-4].yy_sctrl);
		}
		if (yyvsp[-3].yy_action && yyval.yy_type->yp_action1 == NULLCP) {
			yyval.yy_type->yp_action1 = yyvsp[-3].yy_action->ya_text;
			yyval.yy_type->yp_act1_lineno = yyvsp[-3].yy_action->ya_lineno;
			free_action(yyvsp[-3].yy_action);
		} else if (yyvsp[-3].yy_action)
			yyerror("too many actions associated with SET");
	}
		break;
	case 65:
#line 492 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
		yyval.yy_type->yp_tag = yyvsp[-3].yy_tag;
		if (yyvsp[-2].yy_action && yyval.yy_type->yp_action1 == NULLCP) {
			yyval.yy_type->yp_action1 = yyvsp[-2].yy_action->ya_text;
			yyval.yy_type->yp_act1_lineno = yyvsp[-2].yy_action->ya_lineno;
			free_action(yyvsp[-2].yy_action);
		} else if (yyvsp[-2].yy_action)
			yyerror("too many actions associated with tagged type");
		yyval.yy_type->yp_flags |= YP_IMPLICIT | YP_TAG;
	}
		break;
	case 66:
#line 504 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
		yyval.yy_type->yp_tag = yyvsp[-3].yy_tag;
		if (yyvsp[-2].yy_action && yyval.yy_type->yp_action1 == NULLCP) {
			yyval.yy_type->yp_action1 = yyvsp[-2].yy_action->ya_text;
			yyval.yy_type->yp_act1_lineno = yyvsp[-2].yy_action->ya_lineno;
			free_action(yyvsp[-2].yy_action);
		} else if (yyvsp[-2].yy_action)
			yyerror("too many actions associated with tagged type");
		yyval.yy_type->yp_flags |= YP_TAG;
	}
		break;
	case 67:
#line 516 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
		yyval.yy_type->yp_tag = yyvsp[-2].yy_tag;
		if (yyvsp[-1].yy_action && yyval.yy_type->yp_action1 == NULLCP) {
			yyval.yy_type->yp_action1 = yyvsp[-1].yy_action->ya_text;
			yyval.yy_type->yp_act1_lineno = yyvsp[-1].yy_action->ya_lineno;
			free_action(yyvsp[-1].yy_action);
		} else if (yyvsp[-1].yy_action)
			yyerror("too many actions associated with tagged type");
		yyval.yy_type->yp_flags |= (YP_TAG | tagdefault);
	}
		break;
	case 68:
#line 529 "yacc.y"
	{
		yyval.yy_type = new_type(YP_CHOICE);
		yyval.yy_type->yp_type = yyvsp[-1].yy_type;
		if (yyvsp[-5].yy_sctrl) {
			yyval.yy_type->yp_structname = yyvsp[-5].yy_sctrl->ys_structname;
			yyval.yy_type->yp_ptrname = yyvsp[-5].yy_sctrl->ys_ptrname;
			free_ys(yyvsp[-5].yy_sctrl);
		}
		if (yyvsp[-3].yy_string) {
			yyval.yy_type->yp_control = yyvsp[-3].yy_string;
			yyval.yy_type->yp_flags |= YP_CONTROLLED;
		}
		if (yyval.yy_type->yp_action1 == NULLCP && yyvsp[-4].yy_action) {
			yyval.yy_type->yp_action1 = yyvsp[-4].yy_action->ya_text;
			yyval.yy_type->yp_act1_lineno = yyvsp[-4].yy_action->ya_lineno;
			free_action(yyvsp[-4].yy_action);
		} else if (yyvsp[-4].yy_action)
			yyerror("too many actions associated with CHOICE");
	}
		break;
	case 69:
#line 549 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
		yyval.yy_type->yp_bound = yyvsp[-2].yy_string;
		yyval.yy_type->yp_flags |= YP_BOUND;
	}
		break;
	case 70:
#line 554 "yacc.y"
	{
		yyval.yy_type = new_type(YP_ANY);
		yyval.yy_type->yp_strexp = yyvsp[0].yy_string;
	}
		break;
	case 71:
#line 558 "yacc.y"
	{
		yyval.yy_type = new_type(YP_OID);
		yyval.yy_type->yp_strexp = yyvsp[0].yy_string;
	}
		break;
	case 72:
#line 562 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
		yyval.yy_type->yp_tag = new_tag(PE_CLASS_UNIV);
		yyval.yy_type->yp_tag->yt_value = new_value(YV_NUMBER);
		yyval.yy_type->yp_tag->yt_value->yv_number = PE_PRIM_ENCR;
		yyval.yy_type->yp_flags |= (YP_ENCRYPTED | YP_TAG | YP_IMPLICIT);
	}
		break;
	case 73:
#line 570 "yacc.y"
	{
		yyval.yy_type = new_type(YP_REAL);
		yyval.yy_type->yp_strexp = yyvsp[0].yy_string;
	}
		break;
	case 74:
#line 576 "yacc.y"
	{
		yyval.yy_value = yyvsp[-1].yy_value;
	}
		break;
	case 75:
#line 577 "yacc.y"
	{
		yyval.yy_value = NULL;
	}
		break;
	case 76:
#line 579 "yacc.y"
	{
		yyval.yy_type = yyvsp[-1].yy_type;
		yyval.yy_type->yp_code = YP_IDEFINED;
		yyval.yy_type->yp_identifier = yyvsp[-2].yy_string;
		if (yyvsp[0].yy_string) {
			yyval.yy_type->yp_parm = yyvsp[0].yy_string;
			yyval.yy_type->yp_flags |= YP_PARMVAL;
		}
		check_impexp(yyval.yy_type);
	}
		break;
	case 77:
#line 589 "yacc.y"
	{
		yyval.yy_type = yyvsp[-1].yy_type;
		yyval.yy_type->yp_code = YP_IDEFINED;
		yyval.yy_type->yp_identifier = yyvsp[-2].yy_string;
		yyval.yy_type->yp_module = yyvsp[-4].yy_string;
		if (yyvsp[0].yy_string) {
			yyval.yy_type->yp_parm = yyvsp[0].yy_string;
			yyval.yy_type->yp_flags |= YP_PARMVAL;
		}
	}
		break;
	case 78:
#line 601 "yacc.y"
	{
		yyval.yy_type = new_type(YP_UNDF);
		yyval.yy_type->yp_intexp = NULLCP;
		yyval.yy_type->yp_strexp = yyvsp[0].yy_string;
		yyval.yy_type->yp_prfexp = 'a';
	}
		break;
	case 79:
#line 607 "yacc.y"
	{
		yyval.yy_type = new_type(YP_UNDF);
		yyval.yy_type->yp_intexp = yyvsp[0].yy_string;
		yyval.yy_type->yp_strexp = NULLCP;
		yyval.yy_type->yp_prfexp = 'b';
	}
		break;
	case 80:
#line 613 "yacc.y"
	{
		yyval.yy_type = new_type(YP_UNDF);
		yyval.yy_type->yp_intexp = yyvsp[0].yy_string;
		yyval.yy_type->yp_strexp = NULLCP;
		yyval.yy_type->yp_prfexp = 'i';
	}
		break;
	case 81:
#line 619 "yacc.y"
	{
		yyval.yy_type = new_type(YP_UNDF);
		yyval.yy_type->yp_intexp = yyvsp[0].yy_string;
		yyval.yy_type->yp_strexp = yyvsp[-1].yy_string;
		yyval.yy_type->yp_prfexp = 'x';
	}
		break;
	case 82:
#line 625 "yacc.y"
	{
		yyval.yy_type = new_type(YP_UNDF);
		yyval.yy_type->yp_intexp = NULLCP;
		yyval.yy_type->yp_strexp = yyvsp[0].yy_string;
		yyval.yy_type->yp_prfexp = 'O';
	}
		break;
	case 87:
#line 639 "yacc.y"
	{
		yyval.yy_string = NULLCP;
	}
		break;
	case 89:
#line 643 "yacc.y"
	{
		yyval.yy_string = NULLCP;
	}
		break;
	case 91:
#line 647 "yacc.y"
	{
		yyval.yy_string = NULLCP;
	}
		break;
	case 93:
#line 651 "yacc.y"
	{
		yyval.yy_string = NULLCP;
	}
		break;
	case 94:
#line 654 "yacc.y"
	{
		yyval.yy_type = new_type(YP_UNDF);
		yyval.yy_type->yp_intexp = yyvsp[0].yy_string;
		yyval.yy_type->yp_strexp = yyvsp[-1].yy_string;
	}
		break;
	case 96:
#line 662 "yacc.y"
	{
		yyval.yy_type = new_type(YP_UNDF);
		yyval.yy_type->yp_intexp = NULLCP;
		yyval.yy_type->yp_strexp = yyvsp[0].yy_string;
		yyval.yy_type->yp_prfexp = 's';
	}
		break;
	case 97:
#line 668 "yacc.y"
	{
		yyval.yy_type = new_type(YP_UNDF);
		yyval.yy_type->yp_intexp = yyvsp[0].yy_string;
		yyval.yy_type->yp_strexp = yyvsp[-1].yy_string;
		yyval.yy_type->yp_prfexp = 'o';
	}
		break;
	case 98:
#line 674 "yacc.y"
	{
		yyval.yy_type = new_type(YP_UNDF);
		yyval.yy_type->yp_intexp = NULLCP;
		yyval.yy_type->yp_strexp = yyvsp[0].yy_string;
		yyval.yy_type->yp_prfexp = 'q';
	}
		break;
	case 101:
#line 684 "yacc.y"
	{
		yyval.yy_string = NULLCP;
	}
		break;
	case 102:
#line 687 "yacc.y"
	{
		yyval.yy_type = new_type(YP_UNDF);
		yyval.yy_type->yp_intexp = NULLCP;
		yyval.yy_type->yp_strexp = NULLCP;
	}
		break;
	case 104:
#line 695 "yacc.y"
	{
		yyval.yy_string = NULLCP;
	}
		break;
	case 105:
#line 698 "yacc.y"
	{
		yyval.yy_value = yyvsp[0].yy_value;
	}
		break;
	case 106:
#line 699 "yacc.y"
	{
		yyval.yy_value = add_value(yyvsp[-2].yy_value, yyvsp[0].yy_value);
	}
		break;
	case 107:
#line 703 "yacc.y"
	{
		yyval.yy_value = yyvsp[-2].yy_value;
		yyval.yy_value->yv_named = yyvsp[-4].yy_string;
		yyval.yy_value->yv_flags |= YV_NAMED;
		if (yyvsp[0].yy_action) {
			yyval.yy_value->yv_action = yyvsp[0].yy_action->ya_text;
			yyval.yy_value->yv_act_lineno = yyvsp[0].yy_action->ya_lineno;
			free_action(yyvsp[0].yy_action);
		}
	}
		break;
	case 108:
#line 714 "yacc.y"
	{
		yyval.yy_value = new_value(YV_NUMBER);
		yyval.yy_value->yv_number = yyvsp[0].yy_number;
	}
		break;
	case 110:
#line 721 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
	}
		break;
	case 111:
#line 722 "yacc.y"
	{
		yyval.yy_type = NULLYP;
	}
		break;
	case 112:
#line 724 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
	}
		break;
	case 113:
#line 726 "yacc.y"
	{
		yyval.yy_type = NULLYP;
	}
		break;
	case 114:
#line 728 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
	}
		break;
	case 115:
#line 729 "yacc.y"
	{
		yyval.yy_type = add_type(yyvsp[-2].yy_type, yyvsp[0].yy_type);
	}
		break;
	case 116:
#line 733 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
	}
		break;
	case 117:
#line 734 "yacc.y"
	{
		yyval.yy_type = yyvsp[-2].yy_type;
		yyval.yy_type->yp_flags |= YP_OPTIONAL;
		if (yyvsp[0].yy_string) {
			yyval.yy_type->yp_optcontrol = yyvsp[0].yy_string;
			yyval.yy_type->yp_flags |= YP_OPTCONTROL;
		}
	}
		break;
	case 118:
#line 742 "yacc.y"
	{
		yyval.yy_type = yyvsp[-3].yy_type;
		yyval.yy_type->yp_default = yyvsp[-1].yy_value;
		yyval.yy_type->yp_flags |= YP_DEFAULT;
		if (yyvsp[0].yy_string) {
			yyval.yy_type->yp_optcontrol = yyvsp[0].yy_string;
			yyval.yy_type->yp_flags |= YP_OPTCONTROL;
		}
	}
		break;
	case 119:
#line 751 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
	}
		break;
	case 120:
#line 752 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
		yyval.yy_type->yp_id = yyvsp[-1].yy_string;
	}
		break;
	case 121:
#line 754 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
		yyval.yy_type->yp_id = yyvsp[-2].yy_string;
		if (yyval.yy_type->yp_action1 == NULLCP && yyvsp[-1].yy_action) {
			yyval.yy_type->yp_action1 = yyvsp[-1].yy_action->ya_text;
			yyval.yy_type->yp_act1_lineno = yyvsp[-1].yy_action->ya_lineno;
			free_action(yyvsp[-1].yy_action);
		}
		yyval.yy_type->yp_flags |= YP_ID;
	}
		break;
	case 122:
#line 764 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
	}
		break;
	case 123:
#line 766 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
		yyval.yy_type->yp_flags |= YP_COMPONENTS;
	}
		break;
	case 124:
#line 771 "yacc.y"
	{
		yyval.yy_type = yyvsp[0].yy_type;
	}
		break;
	case 125:
#line 772 "yacc.y"
	{
		yyval.yy_type = add_type(yyvsp[-2].yy_type, yyvsp[0].yy_type);
	}
		break;
	case 126:
#line 777 "yacc.y"
	{
		yyval.yy_tag = yyvsp[-2].yy_tag;
		yyval.yy_tag->yt_value = yyvsp[-1].yy_value;
	}
		break;
	case 127:
#line 782 "yacc.y"
	{
		yyval.yy_tag = new_tag(PE_CLASS_UNIV);
	}
		break;
	case 128:
#line 783 "yacc.y"
	{
		yyval.yy_tag = new_tag(PE_CLASS_APPL);
	}
		break;
	case 129:
#line 784 "yacc.y"
	{
		yyval.yy_tag = new_tag(PE_CLASS_PRIV);
	}
		break;
	case 130:
#line 785 "yacc.y"
	{
		yyval.yy_tag = new_tag(PE_CLASS_CONT);
	}
		break;
	case 134:
#line 795 "yacc.y"
	{
		yyval.yy_value = new_value(YV_BOOL);
		yyval.yy_value->yv_number = 1;
	}
		break;
	case 135:
#line 799 "yacc.y"
	{
		yyval.yy_value = new_value(YV_BOOL);
		yyval.yy_value->yv_number = 0;
	}
		break;
	case 136:
#line 803 "yacc.y"
	{
		yyval.yy_value = new_value(YV_NUMBER);
		yyval.yy_value->yv_number = yyvsp[0].yy_number;
	}
		break;
	case 137:
#line 807 "yacc.y"
	{
		yyval.yy_value = new_value(YV_IDLIST);
		yyval.yy_value->yv_idlist = new_value(YV_IDEFINED);
		yyval.yy_value->yv_idlist->yv_identifier = yyvsp[-2].yy_string;
		if (yyvsp[-1].yy_value)
			yyval.yy_value = add_value(yyval.yy_value, yyvsp[-1].yy_value);
	}
		break;
	case 138:
#line 814 "yacc.y"
	{
		yyval.yy_value = new_value(YV_STRING);
		yyval.yy_value->yv_string = yyvsp[0].yy_string;
	}
		break;
	case 139:
#line 818 "yacc.y"
	{
		yyval.yy_value = new_value(YV_NULL);
	}
		break;
	case 140:
#line 819 "yacc.y"
	{
		yyval.yy_value = new_value(YV_VALIST);
		yyval.yy_value->yv_idlist = yyvsp[-1].yy_value;
	}
		break;
	case 141:
#line 823 "yacc.y"
	{
		yyval.yy_value = yyvsp[0].yy_value;
		yyval.yy_value->yv_id = yyvsp[-1].yy_string;
		yyval.yy_value->yv_flags |= YV_ID;
	}
		break;
	case 142:
#line 828 "yacc.y"
	{
		yyval.yy_value = yyvsp[0].yy_value;
		yyval.yy_value->yv_type = yyvsp[-1].yy_type;
		yyval.yy_value->yv_flags |= YV_TYPE;
	}
		break;
	case 143:
#line 833 "yacc.y"
	{
		yyval.yy_value = new_value(YV_REAL);
		yyval.yy_value->yv_real = yyvsp[0].yy_real;
	}
		break;
	case 146:
#line 843 "yacc.y"
	{
		yyval.yy_real = PE_REAL_INFINITY;
	}
		break;
	case 147:
#line 844 "yacc.y"
	{
		yyval.yy_real = -PE_REAL_INFINITY;
	}
		break;
	case 148:
#line 848 "yacc.y"
	{
		if (yyvsp[-3].yy_number != 2 && yyvsp[-3].yy_number != 10)
			myyerror("Illegal base value %d", yyvsp[-3].yy_number);
		yyval.yy_real =
		    yyvsp[-5].yy_number * pow((double) yyvsp[-3].yy_number,
					      (double) yyvsp[-1].yy_number);
	}
		break;
	case 149:
#line 855 "yacc.y"
	{
		yyval.yy_value = new_value(YV_IDEFINED);
		yyval.yy_value->yv_identifier = yyvsp[0].yy_string;
	}
		break;
	case 150:
#line 859 "yacc.y"
	{			/* XXX */
		yyval.yy_value = new_value(YV_IDEFINED);
		yyval.yy_value->yv_identifier = yyvsp[0].yy_string;
		yyval.yy_value->yv_flags |= YV_BOUND;
	}
		break;
	case 151:
#line 864 "yacc.y"
	{
		yyval.yy_value = new_value(YV_IDEFINED);
		yyval.yy_value->yv_identifier = yyvsp[0].yy_string;
		yyval.yy_value->yv_module = yyvsp[-2].yy_string;
	}
		break;
	case 152:
#line 871 "yacc.y"
	{
		yyval.yy_value = new_value(YV_IDEFINED);
		yyval.yy_value->yv_identifier = yyvsp[0].yy_string;
		if (yyvsp[-2].yy_value)
			yyval.yy_value = add_value(yyvsp[-2].yy_value, yyval.yy_value);
	}
		break;
	case 153:
#line 877 "yacc.y"
	{
		yyval.yy_value = NULLYV;
	}
		break;
	case 154:
#line 880 "yacc.y"
	{
		yyval.yy_value = yyvsp[0].yy_value;
	}
		break;
	case 155:
#line 881 "yacc.y"
	{
		yyval.yy_value = NULLYV;
	}
		break;
	case 156:
#line 883 "yacc.y"
	{
		yyval.yy_value = yyvsp[0].yy_value;
	}
		break;
	case 157:
#line 884 "yacc.y"
	{
		yyval.yy_value = add_value(yyvsp[-2].yy_value, yyvsp[0].yy_value);
	}
		break;
	case 158:
#line 888 "yacc.y"
	{
		yyval.yy_value = yyvsp[0].yy_value;
	}
		break;
	case 170:
#line 912 "yacc.y"
	{
		yyval.yy_oid = yyvsp[-1].yy_oid;
	}
		break;
	case 172:
#line 917 "yacc.y"
	{
		yyval.yy_oid = addoid(yyvsp[-1].yy_oid, yyvsp[0].yy_oid);
		oid_free(yyvsp[-1].yy_oid);
		oid_free(yyvsp[0].yy_oid);
	}
		break;
	case 175:
#line 928 "yacc.y"
	{
		yyval.yy_oid = int2oid(yyvsp[0].yy_number);
	}
		break;
	case 176:
#line 929 "yacc.y"
	{
		yyval.yy_oid = oidlookup(yyvsp[0].yy_value->yv_identifier);
		free((char *) yyvsp[0].yy_value);
	}
		break;
	case 177:
#line 935 "yacc.y"
	{
		free(yyvsp[-3].yy_string);
		yyval.yy_oid = yyvsp[-1].yy_oid;
	}
		break;
	case 179:
#line 942 "yacc.y"
	{
		yyval.yy_type = new_type(YP_SETTYPE);
		yyval.yy_type->yp_type = yyvsp[0].yy_type;
		if (yyvsp[-3].yy_sctrl) {
			yyval.yy_type->yp_structname = yyvsp[-3].yy_sctrl->ys_structname;
			yyval.yy_type->yp_ptrname = yyvsp[-3].yy_sctrl->ys_ptrname;
			free_ys(yyvsp[-3].yy_sctrl);
		}
		if (yyvsp[-1].yy_string) {
			yyval.yy_type->yp_control = yyvsp[-1].yy_string;
			yyval.yy_type->yp_flags |= YP_CONTROLLED;
		}
		if (yyvsp[-2].yy_action) {
			yyval.yy_type->yp_action3 = yyvsp[-2].yy_action->ya_text;
			yyval.yy_type->yp_act2_lineno = yyvsp[-2].yy_action->ya_lineno;
			free_action(yyvsp[-2].yy_action);
		}
	}
		break;
	case 180:
#line 961 "yacc.y"
	{
		yyval.yy_type = new_type(YP_SEQTYPE);
		yyval.yy_type->yp_type = yyvsp[0].yy_type;
		if (yyvsp[-3].yy_sctrl) {
			yyval.yy_type->yp_structname = yyvsp[-3].yy_sctrl->ys_structname;
			yyval.yy_type->yp_ptrname = yyvsp[-3].yy_sctrl->ys_ptrname;
			free_ys(yyvsp[-3].yy_sctrl);
		}
		if (yyvsp[-1].yy_string) {
			yyval.yy_type->yp_control = yyvsp[-1].yy_string;
			yyval.yy_type->yp_flags |= YP_CONTROLLED;
		}
		if (yyvsp[-2].yy_action) {
			yyval.yy_type->yp_action3 = yyvsp[-2].yy_action->ya_text;
			yyval.yy_type->yp_act3_lineno = yyvsp[-2].yy_action->ya_lineno;
			free_action(yyvsp[-2].yy_action);
		}
	}
		break;
	case 221:
#line 1066 "yacc.y"
	{
		yyval.yy_sctrl = new_ys(yyvsp[0].yy_string);
	}
		break;
	case 222:
#line 1067 "yacc.y"
	{
		yyval.yy_sctrl = NULLYS;
	}
		break;
#line 2373 "y.tab.c"
	}
	yyssp -= yym;
	yystate = *yyssp;
	yyvsp -= yym;
	yym = yylhs[yyn];
	if (yystate == 0 && yym == 0) {
#if YYDEBUG
		if (yydebug)
			printf("yydebug: after reduction, shifting from state 0 to\
 state %d\n", YYFINAL);
#endif
		yystate = YYFINAL;
		*++yyssp = YYFINAL;
		*++yyvsp = yyval;
		if (yychar < 0) {
			if ((yychar = yylex()) < 0)
				yychar = 0;
#if YYDEBUG
			if (yydebug) {
				yys = 0;
				if (yychar <= YYMAXTOKEN)
					yys = yyname[yychar];
				if (!yys)
					yys = "illegal-symbol";
				printf("yydebug: state %d, reading %d (%s)\n",
				       YYFINAL, yychar, yys);
			}
#endif
		}
		if (yychar == 0)
			goto yyaccept;
		goto yyloop;
	}
	if ((yyn = yygindex[yym]) && (yyn += yystate) >= 0 &&
	    yyn <= YYTABLESIZE && yycheck[yyn] == yystate)
		yystate = yytable[yyn];
	else
		yystate = yydgoto[yym];
#if YYDEBUG
	if (yydebug)
		printf("yydebug: after reduction, shifting from state %d \
to state %d\n", *yyssp, yystate);
#endif
	if (yyssp >= yyss + yystacksize - 1) {
		goto yyoverflow;
	}
	*++yyssp = yystate;
	*++yyvsp = yyval;
	goto yyloop;
      yyoverflow:
	yyerror("yacc stack overflow");
      yyabort:
	return (1);
      yyaccept:
	return (0);
}
